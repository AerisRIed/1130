# pma_cmn_registers: IP-XACT component
VLNV cadence:cdns_lib:pma_cmn_registers:1685-2009

## Address spaces and blocks
sd3101_t4_registers.sd3101_phy_registers: base 0x0, range 0x1fff, width 32

## Registers
Registers are 32-bit, read-write, reset 0x0 unless marked. A register's access mark holds for its fields unless they carry their own. Offsets are from the block's base; lines under a group give offsets from that group; [hi:lo] are bit positions; {n}, {i} and the like mark numbered series; 'fields as' and 'values as' point back to an identical list; <NAME> marks a mode.

## sd3101_t4_registers.sd3101_phy_registers
Base 0x00000000
0x00 cmn_pid_type reset 0x7364 — Product type ID register
  [31:16] cmn_pid_type_31_16 ro — Reserved
  [15:0] cmn_pid_type_15_0 ro — Product type
0x0C cmn_pid_num reset 0x3101 — Product number ID register
  [31:16] cmn_pid_num_31_16 ro — Reserved
  [15:0] cmn_pid_num_15_0 ro
0x10 cmn_pid_rev reset 0x100 — Product revision ID register
  [31:16] cmn_pid_rev_31_16 ro — Reserved
  [15:0] cmn_pid_rev_15_0 ro — Product revision
0x20 cmn_pid_mfg reset 0x74 — Product technology manufacturer ID register
  [31:16] cmn_pid_mfg_31_16 ro — Reserved
  [15:0] cmn_pid_mfg_15_0 ro
0x24 cmn_pid_node reset 0x4 — Product technology process node ID register
  [31:16] cmn_pid_node_31_16 ro — Reserved
  [15:0] cmn_pid_node_15_0 ro — Product technology process node
0x28 cmn_pid_flv0 reset 0x6770 — Product technology process flavor ID register 0
  [31:16] cmn_pid_flv0_31_16 ro — Reserved
  [15:0] cmn_pid_flv0_15_0 ro
0x2C cmn_pid_flv1 — Product technology process flavor ID register 1
  [31:16] cmn_pid_flv1_31_16 ro — Reserved
  [15:0] cmn_pid_flv1_15_0 ro — Product technology flavor
0x30 cmn_pid_iov reset 0x120 — Product I/O voltage ID register
  [31:16] cmn_pid_iov_31_16 ro — Reserved
  [15:0] cmn_pid_iov_15_0 ro — Product I/O voltage
0x34 cmn_pid_lanes reset 0x202 — Product SerDes lanes ID register
  [31:16] cmn_pid_lanes_31_16 ro — Reserved
  [15:8] cmn_pid_lanes_15_8 ro — 2 lanes on the left side of common.
  [7:0] cmn_pid_lanes_7_0 ro — 2 lanes on the right side of common.
{0x40+4i} cmn_pid_metal{i} (i=0..3) — Product metal layers ID register {i}
  [31:16] cmn_pid_metal{i}_31_16 ro — Reserved
  [15:0] cmn_pid_metal{i}_15_0 ro — Reserved
0x50 cmn_pid_metald reset 0x5555 — Product metal layer direction ID register
  [31:16] cmn_pid_metald_31_16 ro — Reserved
  [n] cmn_pid_metald_{n} ro (n=9..15) — Metal {n} direction (when used) : 1'b0 = Vertical, 1'b1 = Horizontal
  [n] cmn_pid_metald_{n} ro (n=1..8) — Metal {n} direction : 1'b0 = Vertical, 1'b1 = Horizontal
  [0] cmn_pid_metald_0 ro — Metal 0 direction : This layer does not have a direction associated with it.
0x80 cmn_ssm_sm_ctrl reset 0x10003 — Startup state machine control register
  [n] cmn_ssm_sm_ctrl_{n} (n=24..31)
  [23:18] cmn_ssm_sm_ctrl_23_18 — Reserved for user defined control bits - spare
  [17] cmn_ssm_sm_ctrl_17 — Force SSM gated clock on
  [16] cmn_ssm_sm_ctrl_16
  [15:12] cmn_ssm_sm_ctrl_15_12 ro — Reserved
  [11] cmn_ssm_sm_ctrl_11
  [10] cmn_ssm_sm_ctrl_10 — Pre calibration enable override
  [9] cmn_ssm_sm_ctrl_9
  [8] cmn_ssm_sm_ctrl_8 — Post calibration enable override
  [7] cmn_ssm_sm_ctrl_7
  [6] cmn_ssm_sm_ctrl_6 — Note: The bandgap enable hold enable bit in this register must also be set to 1'b0 in order for this register to function correctly.
  [5] cmn_ssm_sm_ctrl_5
  [4] cmn_ssm_sm_ctrl_4 — Bias enable override
  [3:2] cmn_ssm_sm_ctrl_3_2 ro — Reserved
  [1] cmn_ssm_sm_ctrl_1
  [0] cmn_ssm_sm_ctrl_0 — Skip auto re-calibration
0x84 cmn_ssm_tmr_1 reset 0x10019 — Startup state machine timer 1 register
  [31:21] cmn_ssm_tmr_1_31_21 ro — Reserved
  [20:16] cmn_ssm_tmr_1_20_16 — Note, when exiting common suspend mode, a total of 1000 nSec is required for the bandgap to be enabled. This total delay is what is ultimately used to determine what the delay needs to be in the band- gap enable state. Of this total time, 960 nSec of this time is accounted for in the suspend recovery state. The remainder is accounted for here.
  [15:7] cmn_ssm_tmr_1_15_7 ro — Reserved
  [6:0] cmn_ssm_tmr_1_6_0
0x88 cmn_ssm_tmr_2 reset 0x10001 — Startup state machine timer 2 register
  [31:20] cmn_ssm_tmr_2_31_20 ro — Reserved
  [19:16] cmn_ssm_tmr_2_19_16 — Pre calibration enable state timer value
  [15:4] cmn_ssm_tmr_2_15_4 ro — Reserved
  [3:0] cmn_ssm_tmr_2_3_0 — Post calibration enable state timer value
0x8C cmn_ssm_st — Startup state machine current state register
  [31:16] cmn_ssm_st_31_16 ro — Reserved
  [15:10] cmn_ssm_st_15_10 ro — Reserved
  [9:0] cmn_ssm_st_9_0 ro — Startup state machine current state
0xA0 cmn_pllsm0_sm_ctrl reset 0x2 — PLL 0 control state machine control register
  [n] cmn_pllsm0_sm_ctrl_{n} (n=28..31)
  [27:17] cmn_pllsm0_sm_ctrl_27_17 — Reserved for user defined control bits - spare
  [16] cmn_pllsm0_sm_ctrl_16 — PLL lock override
  [15:14] cmn_pllsm0_sm_ctrl_15_14 ro — Reserved
  [13] cmn_pllsm0_sm_ctrl_13
  [12] cmn_pllsm0_sm_ctrl_12 — PLL alternate enable override
  [11] cmn_pllsm0_sm_ctrl_11
  [10] cmn_pllsm0_sm_ctrl_10 — PLL regulator enable override:
  [9] cmn_pllsm0_sm_ctrl_9
  [8] cmn_pllsm0_sm_ctrl_8 — PLL enable override
  [7] cmn_pllsm0_sm_ctrl_7
  [6] cmn_pllsm0_sm_ctrl_6 — PLL reset override
  [5] cmn_pllsm0_sm_ctrl_5
  [4] cmn_pllsm0_sm_ctrl_4 — PLL pre charge override
  [3:2] cmn_pllsm0_sm_ctrl_3_2 ro — Reserved
  [1] cmn_pllsm0_sm_ctrl_1
  [0] cmn_pllsm0_sm_ctrl_0
0xA4 cmn_pllsm0_tmr_1 reset 0x190001 — PLL 0 timer 1 register
  [31:24] cmn_pllsm0_tmr_1_31_24 ro — Reserved
  [23:16] cmn_pllsm0_tmr_1_23_16
  [15:4] cmn_pllsm0_tmr_1_15_4 ro — Reserved
  [3:0] cmn_pllsm0_tmr_1_3_0 — PLL regulator enable state timer value
0xA8 cmn_pllsm0_tmr_2 reset 0x1003F — PLL 0 timer 2 register
  [31:20] cmn_pllsm0_tmr_2_31_20 ro — Reserved
  [19:16] cmn_pllsm0_tmr_2_19_16 — PLL alternate enable state timer value
  [15:8] cmn_pllsm0_tmr_2_15_8 ro — Reserved
  [7:0] cmn_pllsm0_tmr_2_7_0
0xAC cmn_pllsm0_tmr_3 reset 0x100FA — PLL 0 timer 3 register
  [31:20] cmn_pllsm0_tmr_3_31_20 ro — Reserved
  [19:16] cmn_pllsm0_tmr_3_19_16 — PLL VREF delay state timer value
  [15:10] cmn_pllsm0_tmr_3_15_10 ro — Reserved
  [9:0] cmn_pllsm0_tmr_3_9_0 — PLL lock delay state timer value
0xB0 cmn_pllsm0_tmr_4 reset 0x1 — PLL 0 timer 4 register
  [31:16] cmn_pllsm0_tmr_4_31_16 ro — Reserved
  [15:2] cmn_pllsm0_tmr_4_15_2 ro — Reserved
  [1:0] cmn_pllsm0_tmr_4_1_0
0xB4 cmn_pllsm0_st — PLL 0 control state machine current state register
  [31:16] cmn_pllsm0_st_31_16 ro — Reserved
  [15:14] cmn_pllsm0_st_15_14 ro — Reserved
  [13:0] cmn_pllsm0_st_13_0 ro — PLL control state machine current state
0xC0 cmn_pllsm1_sm_ctrl0 — PLL 1 control state machine control 0 register
  [31] cmn_pllsm1_sm_ctrl0_31
  [30] cmn_pllsm1_sm_ctrl0_30 — PLL program divided enable override:
  [29] cmn_pllsm1_sm_ctrl0_29
  [28] cmn_pllsm1_sm_ctrl0_28 — PLL lock detection enable override:
  [27] cmn_pllsm1_sm_ctrl0_27
  [26] cmn_pllsm1_sm_ctrl0_26 — PLL down frc enable override:
  [25] cmn_pllsm1_sm_ctrl0_25
  [24] cmn_pllsm1_sm_ctrl0_24 — PLL up frc enable override:
  [23] cmn_pllsm1_sm_ctrl0_23
  [22] cmn_pllsm1_sm_ctrl0_22 — PLL fbdiv power reset override:
  [21] cmn_pllsm1_sm_ctrl0_21
  [20] cmn_pllsm1_sm_ctrl0_20 — PLL fbdiv power enable delay override:
  [19] cmn_pllsm1_sm_ctrl0_19
  [18] cmn_pllsm1_sm_ctrl0_18 — PLL fbdiv power enable override:
  [17] cmn_pllsm1_sm_ctrl0_17
  [16] cmn_pllsm1_sm_ctrl0_16 — PLL cpen sb enable override:
  [15] cmn_pllsm1_sm_ctrl0_15
  [14] cmn_pllsm1_sm_ctrl0_14 — PLL vco filter bypass override:
  [13] cmn_pllsm1_sm_ctrl0_13
  [12] cmn_pllsm1_sm_ctrl0_12 — PLL cpen cp enable override
  [11] cmn_pllsm1_sm_ctrl0_11
  [10] cmn_pllsm1_sm_ctrl0_10 — PLL vco vctrl init override:
  [9] cmn_pllsm1_sm_ctrl0_9
  [8] cmn_pllsm1_sm_ctrl0_8 — PLL cppd enable override
  [7] cmn_pllsm1_sm_ctrl0_7
  [6] cmn_pllsm1_sm_ctrl0_6 — PLL vreg enable delay override
  [5] cmn_pllsm1_sm_ctrl0_5
  [4] cmn_pllsm1_sm_ctrl0_4 — PLL vref filter enable override
  [3] cmn_pllsm1_sm_ctrl0_3
  [2] cmn_pllsm1_sm_ctrl0_2 — PLL vreg enable override :
  [1] cmn_pllsm1_sm_ctrl0_1
  [0] cmn_pllsm1_sm_ctrl0_0 — (pllsmda_pll_en will drive the digital-analog interface pllsmda_pll_vrefout_en directly)
0xC4 cmn_pllsm1_sm_ctrl1 — PLL 1 control state machine control 1 register
  [31:17] cmn_pllsm1_sm_ctrl1_31_17 ro — Reserved
  [16] cmn_pllsm1_sm_ctrl1_16 — This bit is only used in debug mode.
  [15:12] cmn_pllsm1_sm_ctrl1_15_12 ro — Reserved
  [11] cmn_pllsm1_sm_ctrl1_11
  [10] cmn_pllsm1_sm_ctrl1_10 — PLL locked override:
  [9] cmn_pllsm1_sm_ctrl1_9
  [8] cmn_pllsm1_sm_ctrl1_8 — PLL post divide reset_n override:
  [7] cmn_pllsm1_sm_ctrl1_7
  [6] cmn_pllsm1_sm_ctrl1_6 — PLL vco buffer enable override
  [5] cmn_pllsm1_sm_ctrl1_5
  [4] cmn_pllsm1_sm_ctrl1_4 — PLL vco fixed current mode control override:
  [3] cmn_pllsm1_sm_ctrl1_3
  [2] cmn_pllsm1_sm_ctrl1_2 — PLL program divided reset_n override:
  [1] cmn_pllsm1_sm_ctrl1_1
  [0] cmn_pllsm1_sm_ctrl1_0 — PLL program divided delay enable override:
0xC8 cmn_pllsm1_tmr_1 reset 0x640064 — PLL 1 timer 1 register
  [31:16] cmn_pllsm1_tmr_1_31_16
  [15:0] cmn_pllsm1_tmr_1_15_0 — PLL vreg/vref filter enable state timer value
0xCC cmn_pllsm1_tmr_2 reset 0xC80032 — PLL 1 timer 2 register
  [31:16] cmn_pllsm1_tmr_2_31_16 — PLL vreg enable delay state timer value
  [15:0] cmn_pllsm1_tmr_2_15_0 — PLL vco control initialization state timer value
0xD0 cmn_pllsm1_tmr_3 reset 0x320016 — PLL 1 timer 3 register
  [31:16] cmn_pllsm1_tmr_3_31_16 — PLL cpen cp state timer value
  [15:0] cmn_pllsm1_tmr_3_15_0 — PLL fbdiv power enable state timer value
0xD4 cmn_pllsm1_tmr_4 reset 0x160190 — PLL 1 timer 4 register
  [31:16] cmn_pllsm1_tmr_4_31_16 — PLL fbdiv power enable delay state timer value :
  [15:0] cmn_pllsm1_tmr_4_15_0
0xD8 cmn_pllsm1_tmr_5 reset 0x3E803E8 — PLL 1 timer 5 register
  [31:16] cmn_pllsm1_tmr_5_31_16 — PLL up/down frc enable state timer value :
  [15:0] cmn_pllsm1_tmr_5_15_0 — PLL lock enable state timer value:
0xDC cmn_pllsm1_tmr_6 reset 0x1004B0 — PLL 1 timer 6 register
  [31:16] cmn_pllsm1_tmr_6_31_16
  [15:0] cmn_pllsm1_tmr_6_15_0 — PLL lock done delay state timer value:
0xE0 cmn_pllsm1_tmr_7 reset 0x100010 — PLL 1 timer 7 register
  [31:16] cmn_pllsm1_tmr_7_31_16 — PLL program divide enable state timer value :
  [15:0] cmn_pllsm1_tmr_7_15_0 — PLL program divide enable delay state timer value:
0xE4 cmn_pllsm1_tmr_8 reset 0x100010 — PLL 1 timer 8 register
  [31:16] cmn_pllsm1_tmr_8_31_16 — PLL program divide reset_n state timer value
  [15:0] cmn_pllsm1_tmr_8_15_0 — PLL clock disable delay state timer value:
0xE8 cmn_pllsm1_st reset 0x306120 — PLL 1 control state machine current state register
  [31:25] cmn_pllsm1_st_31_25 ro — Reserved
  [24:0] cmn_pllsm1_st_24_0 ro — PLL control state machine current state
0x100 cmn_cdiag_pwri_tmr reset 0x101 — Common power island control timer register
  [31:16] cmn_cdiag_pwri_tmr_31_16 ro — Reserved
  [15:11] cmn_cdiag_pwri_tmr_15_11 ro — Reserved
  [10:8] cmn_cdiag_pwri_tmr_10_8 — Note that a value of 0 in this field is not valid, and will result in a delay of 1 clock cycle.
  [7:3] cmn_cdiag_pwri_tmr_7_3 ro — Reserved
  [2:0] cmn_cdiag_pwri_tmr_2_0 — Note that a value of 0 in this field is not valid, and will result in a delay of 1 clock cycle.
0x108 cmn_cdiag_pllc_pwri_ovrd reset 0x240424 — Note: This register must not be part of any register read write test where patterns other than those described in this register are written to this register.
  [31:24] cmn_cdiag_pllc_pwri_ovrd_31_24 ro — Reserved
  [23:16] cmn_cdiag_pllc_pwri_ovrd_23_16 ro
  [15] cmn_cdiag_pllc_pwri_ovrd_15
  [14] cmn_cdiag_pllc_pwri_ovrd_14
  [13:12] cmn_cdiag_pllc_pwri_ovrd_13_12 ro — Reserved
  [11] cmn_cdiag_pllc_pwri_ovrd_11 — Power suspend request override
  [10] cmn_cdiag_pllc_pwri_ovrd_10 ro
  [9] cmn_cdiag_pllc_pwri_ovrd_9
  [8] cmn_cdiag_pllc_pwri_ovrd_8 ro
  [7:0] cmn_cdiag_pllc_pwri_ovrd_7_0
0x10C cmn_cdiag_ccal_pwri_ovrd reset 0x240424 — Note: This this register must not be part of any register read write test where patterns other than those described in this register are written to this register.
  [31:24] cmn_cdiag_ccal_pwri_ovrd_31_24 ro — Reserved
  [23:16] cmn_cdiag_ccal_pwri_ovrd_23_16 ro
  [15] cmn_cdiag_ccal_pwri_ovrd_15
  [14] cmn_cdiag_ccal_pwri_ovrd_14
  [13:12] cmn_cdiag_ccal_pwri_ovrd_13_12 ro — Reserved
  [11] cmn_cdiag_ccal_pwri_ovrd_11 — Power suspend request override
  [10] cmn_cdiag_ccal_pwri_ovrd_10 ro
  [9] cmn_cdiag_ccal_pwri_ovrd_9 — Power recover request override
  [8] cmn_cdiag_ccal_pwri_ovrd_8 ro
  [7:0] cmn_cdiag_ccal_pwri_ovrd_7_0
0x110 cmn_cdiag_xcvrc_pwri_ovrd reset 0x240424 — Note: This this register must not be part of any register read write test where patterns other than those described in this register are written to this register.
  [31:24] cmn_cdiag_xcvrc_pwri_ovrd_31_24 ro — Reserved
  [23:16] cmn_cdiag_xcvrc_pwri_ovrd_23_16 ro
  [15] cmn_cdiag_xcvrc_pwri_ovrd_15
  [14] cmn_cdiag_xcvrc_pwri_ovrd_14
  [13:12] cmn_cdiag_xcvrc_pwri_ovrd_13_12 ro — Reserved
  [11] cmn_cdiag_xcvrc_pwri_ovrd_11
  [10] cmn_cdiag_xcvrc_pwri_ovrd_10 ro
  [9] cmn_cdiag_xcvrc_pwri_ovrd_9 — Power recover request override
  [8] cmn_cdiag_xcvrc_pwri_ovrd_8 ro
  [7:0] cmn_cdiag_xcvrc_pwri_ovrd_7_0
0x114 cmn_cdiag_diag_pwri_ovrd reset 0xA40424 — Note: This this register must not be part of any register read write test where patterns other than those described in this register are written to this register.
  [31:24] cmn_cdiag_diag_pwri_ovrd_31_24 ro — Reserved
  [23:16] cmn_cdiag_diag_pwri_ovrd_23_16 ro
  [15] cmn_cdiag_diag_pwri_ovrd_15
  [14] cmn_cdiag_diag_pwri_ovrd_14
  [13:12] cmn_cdiag_diag_pwri_ovrd_13_12 ro — Reserved
  [11] cmn_cdiag_diag_pwri_ovrd_11
  [10] cmn_cdiag_diag_pwri_ovrd_10 ro
  [9] cmn_cdiag_diag_pwri_ovrd_9 — Power recover request override
  [8] cmn_cdiag_diag_pwri_ovrd_8 ro
  [7:0] cmn_cdiag_diag_pwri_ovrd_7_0
0x120 cmn_cdiag_refclk_ctrl — Note: If either of the reference clock receiver control registers are required to be written in order to receiver a clean and valid reference clock, then they must be the first registers that is written in the PMA after releasing the CDB from reset.
  [31:1] cmn_cdiag_refclk_ctrl_31_1 ro — Reserved
  [0] cmn_cdiag_refclk_ctrl_0
0x124 cmn_cdiag_psmclk_ctrl reset 0x5 — Power state machine clock receiver control register
  [31:16] cmn_cdiag_psmclk_ctrl_31_16 ro — Reserved
  [15:4] cmn_cdiag_psmclk_ctrl_15_4 ro — Reserved
  [3:0] cmn_cdiag_psmclk_ctrl_3_0
0x128 cmn_cdiag_sdosc_ctrl — Signal detect clock oscillator control register
  [31:16] cmn_cdiag_sdosc_ctrl_31_16 ro — Reserved
  [15:2] cmn_cdiag_sdosc_ctrl_15_2 ro — Reserved
  [1] cmn_cdiag_sdosc_ctrl_1
  [0] cmn_cdiag_sdosc_ctrl_0
0x168 cmn_cdiag_ssm_calmc_cs — SSM calibration multi-cal current state register
  [31:29] cmn_cdiag_ssm_calmc_cs_31_29 ro — Reserved
  [28:16] cmn_cdiag_ssm_calmc_cs_28_16 ro
  [15:4] cmn_cdiag_ssm_calmc_cs_15_4 ro — Reserved
  [3:0] cmn_cdiag_ssm_calmc_cs_3_0 ro — SSM bandgap calibration current state
0x16C cmn_cdiag_pllsm_calmc_cs — PLL SM calibration multi-cal current state register
  [31:7] cmn_cdiag_pllsm_calmc_cs_31_7 ro — Reserved
  [6:0] cmn_cdiag_pllsm_calmc_cs_6_0 ro
0x174 cmn_cdiag_rst_diag — Common control reset diagnostic register
  [31:16] cmn_cdiag_rst_diag_31_16 ro — Reserved
  [15:2] cmn_cdiag_rst_diag_15_2 ro — Reserved
  [1] cmn_cdiag_rst_diag_1 ro — Current state of the cdb_isl_ctrl_sm_reset_n reset.
  [0] cmn_cdiag_rst_diag_0 ro — Current state of the cmn_reset_sync_n reset.
0x17C cmn_cdiag_dcya — Common control cover your alternatives register
  [31:16] cmn_cdiag_dcya_31_16 ro — Reserved
  [15:8] cmn_cdiag_dcya_15_8 ro — Reserved
  [7:0] cmn_cdiag_dcya_7_0 — Reserved - spare
0x180 cmn_bgcal_ctrl — Bandgap calibration control register
  [31:16] cmn_bgcal_ctrl_31_16 ro — Reserved
  [15] cmn_bgcal_ctrl_15
  [14] cmn_bgcal_ctrl_14 ro — Note: Three cmn_ref_clk cycles are required after the start of the calibration process to clear this signal.
  [13] cmn_bgcal_ctrl_13 ro — Note: Due to the nature of the calibration process, it is not possible to determine if the analog responded or not for the lowest code of 5'b10001. The reason for this is, when sequencing to lower codes, the calibration function is looking for the analog response to transition from 1'b1 to 1'b0. If the lowest calibration code is the correct code, the analog will respond with 1'b1, and the algorithm can't sequence to a lower code to look for the transition from 1'b1 to 1'b0. Similarly, if the analog is not responding, it is not possible to sequence to a lower code to detect this. Therefore, even when the calibration function selects this calibration code as valid, this bit will be set.
  [12] cmn_bgcal_ctrl_12 ro
  [11:6] cmn_bgcal_ctrl_11_6 ro — Reserved
  [5:0] cmn_bgcal_ctrl_5_0 ro
0x184 cmn_bgcal_ovrd — Bandgap calibration override register
  [31:16] cmn_bgcal_ovrd_31_16 ro — Reserved
  [15] cmn_bgcal_ovrd_15 — Note: The value of this field must not be changed while the calibration function is running.
  [14] cmn_bgcal_ovrd_14 — Note: The value of this field must not be changed while the calibration function is running.
  [13:6] cmn_bgcal_ovrd_13_6 ro — Reserved
  [5:0] cmn_bgcal_ovrd_5_0 — Note: The value of this field must not be changed while the calibration function is running.
0x188 cmn_bgcal_start — Bandgap calibration start register
  [31:16] cmn_bgcal_start_31_16 ro — Reserved
  [15] cmn_bgcal_start_15
  [14:6] cmn_bgcal_start_14_6 ro — Reserved
  [5:0] cmn_bgcal_start_5_0
0x18C cmn_bgcal_tune — Bandgap calibration tune register
  [31:16] cmn_bgcal_tune_31_16 ro — Reserved
  [15:6] cmn_bgcal_tune_15_6 ro — Reserved
  [5:0] cmn_bgcal_tune_5_0 — Note: This value is a twos complement value, so the calibrated code can be increased or decreased.
0x190 cmn_bgcal_init_tmr reset 0x7D — Bandgap calibration initialization timer register
  [31:16] cmn_bgcal_init_tmr_31_16 ro — Reserved
  [15:9] cmn_bgcal_init_tmr_15_9 ro — Reserved
  [8:0] cmn_bgcal_init_tmr_8_0 — Note: This results in the minimum number of cmn_ref_clk clocks required to wait 5 uSec. Note: This should never be set to a value of less than 1.
0x194 cmn_bgcal_iter_tmr reset 0x87 — Bandgap calibration iteration timer register
  [31:16] cmn_bgcal_iter_tmr_31_16 ro — Reserved
  [15:9] cmn_bgcal_iter_tmr_15_9 ro — Reserved
  [8:0] cmn_bgcal_iter_tmr_8_0
0x1C0 cmn_ibcal_ctrl — External bias current calibration control register
  [31:16] cmn_ibcal_ctrl_31_16 ro — Reserved
  [15] cmn_ibcal_ctrl_15 — Note: This signal is intended to be for diagnostics purposes only. This calibration process is automatically activated internally by the startup state machine. When using this bit, the user must wait until after the internally activated process completes.
  [14] cmn_ibcal_ctrl_14 ro — Note: Three cmn_ref_clk cycles are required after the start of the resistor calibration process to clear this signal.
  [13] cmn_ibcal_ctrl_13 ro — Note: Due to the nature of the calibration process, it is not possible to determine if the analog responded or not for the lowest code of 7'b00000. The reason for this is, when sequencing to lower codes, the calibration function is looking for the analog response to transition from 1'b1 to 1'b0. If the lowest calibration code is the correct code, the analog will respond with 1'b1, and the algorithm can't sequence to a lower code to look for the transition from 1'b1 to 1'b0. Similarly, if the analog is not responding, it is not possible to sequence to a lower code to detect this. Therefore, even when the calibration function selects this calibration code as valid, this bit will be set.
  [12] cmn_ibcal_ctrl_12 ro — Current analog comparator response
  [11:7] cmn_ibcal_ctrl_11_7 ro — Reserved
  [6:0] cmn_ibcal_ctrl_6_0 ro — Note that the most significant bit is the calibration code sign bit, and is always 1'b0 in this application. Note: The reset value for this field is with the common calibration power island switched off. In cases where this power island is switched on, the reset value be 7'b0011111.
0x1C4 cmn_ibcal_ovrd — External bias current calibration override register
  [31:16] cmn_ibcal_ovrd_31_16 ro — Reserved
  [15] cmn_ibcal_ovrd_15
  [14] cmn_ibcal_ovrd_14
  [13:7] cmn_ibcal_ovrd_13_7 ro — Reserved
  [6:0] cmn_ibcal_ovrd_6_0
0x1C8 cmn_ibcal_start reset 0x1F — External bias current calibration start register
  [31:16] cmn_ibcal_start_31_16 ro — Reserved
  [15] cmn_ibcal_start_15
  [14:7] cmn_ibcal_start_14_7 ro — Reserved
  [6:0] cmn_ibcal_start_6_0 — Note that the most significant bit is the calibration code sign bit, and is always 1'b0 in this application.
0x1CC cmn_ibcal_tune — External bias current calibration tune register
  [31:16] cmn_ibcal_tune_31_16 ro — Reserved
  [15:7] cmn_ibcal_tune_15_7 ro — Reserved
  [6:0] cmn_ibcal_tune_6_0 — Note: This value is a twos complement value, so the calibrated code can be increased or decreased.
0x1D0 cmn_ibcal_init_tmr reset 0x1B — External bias current calibration initialization timer register
  [31:16] cmn_ibcal_init_tmr_31_16 ro — Reserved
  [15:7] cmn_ibcal_init_tmr_15_7 ro — Reserved
  [6:0] cmn_ibcal_init_tmr_6_0 — Note: This field should never be set to a value of less than 1.
0x1D4 cmn_ibcal_iter_tmr reset 0x19 — External bias current calibration iteration timer register
  [31:16] cmn_ibcal_iter_tmr_31_16 ro — Reserved
  [15:7] cmn_ibcal_iter_tmr_15_7 ro — Reserved
  [6:0] cmn_ibcal_iter_tmr_6_0
0x200 cmn_pll0_vcocal_ctrl — PLL 0 VCO calibration control register
  [31:16] cmn_pll0_vcocal_ctrl_31_16 ro — Reserved
  [15] cmn_pll0_vcocal_ctrl_15 — Note: This bit is intended to be for diagnostics purposes only. This calibration process is automatically activated internally by the PLL control state machine. When using this bit, the user must wait until after the internally activated process completes.
  [14] cmn_pll0_vcocal_ctrl_14 ro — Note: This bit is not likely to be observed as being set after internal automatic calibration is complete, because the internally generated run signal will be driven inactive immediately after the done signal is activated, and therefore the internal done signal will be cleared.
  [13:8] cmn_pll0_vcocal_ctrl_13_8 ro — Reserved
  [7:0] cmn_pll0_vcocal_ctrl_7_0 ro — Note: The reset value for this field is with the PLL controller power island switched off. In cases where this power island is switched on, the reset value be 8'h28.
0x204 cmn_pll0_vcocal_start reset 0x2074 — PLL 0 VCO calibration start point register
  [31:16] cmn_pll0_vcocal_start_31_16 ro — Reserved
  [15] cmn_pll0_vcocal_start_15 ro — Reserved
  [14:12] cmn_pll0_vcocal_start_14_12
  [11:8] cmn_pll0_vcocal_start_11_8 ro — Reserved
  [7:0] cmn_pll0_vcocal_start_7_0 — Note : This field must be set to a value that is always at least one step size away from the minimum and maximum calibration codes, and is a function of the step size specified in this register. For example, if the initial step size is 4, this value must be at least 4 greater than the minimum calibration code or 4 less than the maximum calibration code.
0x208 cmn_pll0_vcocal_tctrl reset 0x3 — PLL 0 VCO calibration timer control register
  [31:16] cmn_pll0_vcocal_tctrl_31_16 ro — Reserved
  [15:3] cmn_pll0_vcocal_tctrl_15_3 ro — Reserved
  [2:0] cmn_pll0_vcocal_tctrl_2_0 — Note: This divider value must not be set to a value so large that not enough feedback clock edges are sampled to make a good decision. There is no good formula for calculating this constraint. The reduced reference period and expected number of feedback clock edges must be calculated and an analysis per- formed as to if enough edges are available in the reduced time.
0x20C cmn_pll0_vcocal_ovrd — PLL 0 VCO calibration override register
  [31:16] cmn_pll0_vcocal_ovrd_31_16 ro — Reserved
  [15] cmn_pll0_vcocal_ovrd_15
  [14:8] cmn_pll0_vcocal_ovrd_14_8 ro — Reserved
  [7:0] cmn_pll0_vcocal_ovrd_7_0
0x210 cmn_pll0_vcocal_init_tmr reset 0x3E8 — PLL 0 VCO calibration initialization timer register
  [31:16] cmn_pll0_vcocal_init_tmr_31_16 ro — Reserved
  [15:14] cmn_pll0_vcocal_init_tmr_15_14 ro — Reserved
  [13:0] cmn_pll0_vcocal_init_tmr_13_0 — Note: This results in the minimum number of cmn_ref_clk clocks required to wait 10 uSec.
0x214 cmn_pll0_vcocal_iter_tmr reset 0x10 — PLL 0 VCO calibration iteration timer register
  [31:16] cmn_pll0_vcocal_iter_tmr_31_16 ro — Reserved
  [15:14] cmn_pll0_vcocal_iter_tmr_15_14 ro — Reserved
  [13:0] cmn_pll0_vcocal_iter_tmr_13_0
0x218 cmn_pll0_vcocal_reftim_start reset 0xC5E — PLL 0 VCO calibration reference clock timer start value register
  [31:16] cmn_pll0_vcocal_reftim_start_31_16 ro — Reserved
  [15:14] cmn_pll0_vcocal_reftim_start_15_14 ro — Reserved
  [13:0] cmn_pll0_vcocal_reftim_start_13_0 — Note that the actual number of clocks counted is one larger than what is specified by this field.
0x220 cmn_pll0_vcocal_pllcnt_start reset 0x3DDA — PLL 0 VCO calibration PLL clock counter start value register
  [31:16] cmn_pll0_vcocal_pllcnt_start_31_16 ro — Reserved
  [15:0] cmn_pll0_vcocal_pllcnt_start_15_0 — Note that the actual number of clocks counted is one larger than what is specified by this field.
0x240 cmn_pll0_intdiv — PLL 0 feedback divider integer register
  [31:16] cmn_pll0_intdiv_31_16 ro — Reserved
  [15:10] cmn_pll0_intdiv_15_10 ro — Reserved
  [9:0] cmn_pll0_intdiv_9_0 — pll_fb_div_integer value
0x244 cmn_pll0_fracdivl — PLL 0 feedback divider fractional low register
  [31:16] cmn_pll0_fracdivl_31_16 ro — Reserved
  [15:0] cmn_pll0_fracdivl_15_0 — pll_fb_div_fractional
0x248 cmn_pll0_fracdivh — PLL 0 feedback divider fractional high register
  [31:16] cmn_pll0_fracdivh_31_16 ro — Reserved
  [15:3] cmn_pll0_fracdivh_15_3 ro — Reserved
  [2:0] cmn_pll0_fracdivh_2_0 — pll_fb_div_fractional
0x24C cmn_pll0_high_thr — PLL 0 feedback divider high threshold register
  [31:16] cmn_pll0_high_thr_31_16 ro — Reserved
  [15:10] cmn_pll0_high_thr_15_10 ro — Reserved
  [9:0] cmn_pll0_high_thr_9_0
0x250 cmn_pll0_dsm_diag reset 0x4004 — PLL 0 delta sigma modulator diagnostics register
  [31:16] cmn_pll0_dsm_diag_31_16 ro — Reserved
  [15] cmn_pll0_dsm_diag_15
  [14] cmn_pll0_dsm_diag_14 — PLL feedback divider override enable
  [13:4] cmn_pll0_dsm_diag_13_4 ro — Reserved
  [3:0] cmn_pll0_dsm_diag_3_0 — PLL feedback divider latency adjustment
0x254 cmn_pll0_dsm_fbh_ovrd reset 0x40 — PLL 0 delta sigma modulator feedback divider value high override register
  [31:16] cmn_pll0_dsm_fbh_ovrd_31_16 ro — Reserved
  [15:10] cmn_pll0_dsm_fbh_ovrd_15_10 ro — Reserved
  [9:0] cmn_pll0_dsm_fbh_ovrd_9_0
0x258 cmn_pll0_dsm_fbl_ovrd reset 0x1C — PLL 0 delta sigma modulator feedback divider value low override register
  [31:16] cmn_pll0_dsm_fbl_ovrd_31_16 ro — Reserved
  [15:10] cmn_pll0_dsm_fbl_ovrd_15_10 ro — Reserved
  [9:0] cmn_pll0_dsm_fbl_ovrd_9_0
0x260 cmn_pll0_ss_ctrl1 reset 0x2 — PLL 0 spread spectrum control register 1
  [31] cmn_pll0_ss_ctrl1_31 ro — Reserved
  [30:16] cmn_pll0_ss_ctrl1_30_16 — Amplitude step size
  [15] cmn_pll0_ss_ctrl1_15 ro — Reserved
  [14:8] cmn_pll0_ss_ctrl1_14_8 — Note: This field should not be set to 0 when spread spectrum is enabled.
  [7:2] cmn_pll0_ss_ctrl1_7_2 ro — Reserved
  [1] cmn_pll0_ss_ctrl1_1 — Spread spectrum waveform generator disable
  [0] cmn_pll0_ss_ctrl1_0 — Spread spectrum enable during VCO calibration
0x264 cmn_pll0_ss_ctrl2 — PLL 0 spread spectrum control register 2
  [31:16] cmn_pll0_ss_ctrl2_31_16 ro — Reserved
  [15] cmn_pll0_ss_ctrl2_15 ro — Reserved
  [14:8] cmn_pll0_ss_ctrl2_14_8 — Note: The value of this signal must be less than or equal to the value of number of steps field in this register.
  [7] cmn_pll0_ss_ctrl2_7 ro — Reserved
  [6:0] cmn_pll0_ss_ctrl2_6_0 — Note: This field should not be set to 0 when spread spectrum is enabled.
0x268 cmn_pll0_ss_ctrl3 — PLL 0 spread spectrum control register 3
  [31:19] cmn_pll0_ss_ctrl3_31_19 ro — Reserved
  [18:0] cmn_pll0_ss_ctrl3_18_0 — Note: The value of this signal must be equal to spread spectrum wave starting step number * amplitude step size.
0x270 cmn_pll0_lock_refcnt_start reset 0x18F — PLL 0 lock reference counter start value register
  [31:16] cmn_pll0_lock_refcnt_start_31_16 ro — Reserved
  [15:12] cmn_pll0_lock_refcnt_start_15_12 ro — Reserved
  [11:0] cmn_pll0_lock_refcnt_start_11_0
0x274 cmn_pll0_lock_refcnt_idle reset 0x3 — PLL 0 lock reference counter idle value register
  [31:16] cmn_pll0_lock_refcnt_idle_31_16 ro — Reserved
  [15:12] cmn_pll0_lock_refcnt_idle_15_12 ro — Reserved
  [11:0] cmn_pll0_lock_refcnt_idle_11_0
0x278 cmn_pll0_lock_pllcnt_start reset 0x18F — PLL 0 lock PLL counter start value register
  [31:16] cmn_pll0_lock_pllcnt_start_31_16 ro — Reserved
  [15:12] cmn_pll0_lock_pllcnt_start_15_12 ro — Reserved
  [11:0] cmn_pll0_lock_pllcnt_start_11_0 — PLL lock PLL counter start value
0x27C cmn_pll0_lock_pllcnt_thr reset 0x4 — PLL 0 lock PLL counter threshold value register
  [31:16] cmn_pll0_lock_pllcnt_thr_31_16 ro — Reserved
  [15:12] cmn_pll0_lock_pllcnt_thr_15_12 ro — Reserved
  [11:0] cmn_pll0_lock_pllcnt_thr_11_0
0x280 cmn_pll0_varcal_ctrl — PLL 0 varactor trim calibration control register
  [31:16] cmn_pll0_varcal_ctrl_31_16 ro — Reserved
  [15] cmn_pll0_varcal_ctrl_15 — Note: This bit is intended to be for diagnostics purposes only. This calibration process is automatically activated internally by the PLL control state machine. When using this bit, the user must wait until after the internally activated process completes.
  [14] cmn_pll0_varcal_ctrl_14 ro — Note: This bit is not likely to be observed as being set after internal automatic calibration is complete, because the internally generated run signal will be driven inactive immediately after the done signal is activated, and therefore the internal done signal will be cleared.
  [13:12] cmn_pll0_varcal_ctrl_13_12 ro — Reserved
  [11:9] cmn_pll0_varcal_ctrl_11_9 ro — Reserved
  [8] cmn_pll0_varcal_ctrl_8
  [7:5] cmn_pll0_varcal_ctrl_7_5 ro — Reserved
  [4:0] cmn_pll0_varcal_ctrl_4_0 ro — Note: The reset value for this field is with the PLL controller power island switched off. In cases where this power island is switched on, the reset value be 5'h0B.
0x284 cmn_pll0_varcal_start reset 0xB — PLL 0 varactor trim calibration start point register
  [31:16] cmn_pll0_varcal_start_31_16 ro — Reserved
  [15] cmn_pll0_varcal_start_15 ro — Reserved
  [14:12] cmn_pll0_varcal_start_14_12
  [11:5] cmn_pll0_varcal_start_11_5 ro — Reserved
  [4:0] cmn_pll0_varcal_start_4_0 — Note : This field must be set to a value that is always at least one step size away from the minimum and maximum calibration codes, and is a function of the step size specified in this register. For example, if the initial step size is 4, this value must be at least 4 greater than the minimum calibration code or 4 less than the maximum calibration code.
0x288 cmn_pll0_varcal_tctrl — PLL 0 varactor trim calibration timer control register
  [31:16] cmn_pll0_varcal_tctrl_31_16 ro — Reserved
  [15:3] cmn_pll0_varcal_tctrl_15_3 ro — Reserved
  [2:0] cmn_pll0_varcal_tctrl_2_0 — Note: This divider value must not be set to a value so large that not enough feedback clock edges are sampled to make a good decision. There is no good formula for calculating this constraint. The reduced reference period and expected number of feedback clock edges must be calculated and an analysis per- formed as to if enough edges are available in the reduced time.
0x28C cmn_pll0_varcal_ovrd — PLL 0 varactor trim calibration override register
  [31:16] cmn_pll0_varcal_ovrd_31_16 ro — Reserved
  [15] cmn_pll0_varcal_ovrd_15
  [14:5] cmn_pll0_varcal_ovrd_14_5 ro — Reserved
  [4:0] cmn_pll0_varcal_ovrd_4_0
0x290 cmn_pll0_varcal_init_tmr reset 0x3E8 — PLL 0 varactor trim calibration initialization timer register
  [31:16] cmn_pll0_varcal_init_tmr_31_16 ro — Reserved
  [15:14] cmn_pll0_varcal_init_tmr_15_14 ro — Reserved
  [13:0] cmn_pll0_varcal_init_tmr_13_0 — Note: This results in the minimum number of cmn_ref_clk clocks required to wait 10 uSec.
0x294 cmn_pll0_varcal_iter_tmr reset 0x1F4 — PLL 0 varactor trim calibration iteration timer register
  [31:16] cmn_pll0_varcal_iter_tmr_31_16 ro — Reserved
  [15:14] cmn_pll0_varcal_iter_tmr_15_14 ro — Reserved
  [13:0] cmn_pll0_varcal_iter_tmr_13_0 — Note: This results in the minimum number of cmn_ref_clk clocks required to wait 5 uSec.
0x298 cmn_pll0_varcal_reftim_start reset 0xD01 — PLL 0 varactor trim calibration reference clock timer start value register
  [31:16] cmn_pll0_varcal_reftim_start_31_16 ro — Reserved
  [15:14] cmn_pll0_varcal_reftim_start_15_14 ro — Reserved
  [13:0] cmn_pll0_varcal_reftim_start_13_0 — Note that the actual number of clocks counted is one larger than what is specified by this field.
0x29C cmn_pll0_varcal_icvf_init_tmr reset 0xC8 — PLL 0 varactor trim calibration integral control voltage frequency initialization timer register
  [31:16] cmn_pll0_varcal_icvf_init_tmr_31_16 ro — Reserved
  [15:10] cmn_pll0_varcal_icvf_init_tmr_15_10 ro — Reserved
  [9:0] cmn_pll0_varcal_icvf_init_tmr_9_0 — Note: This results in the minimum number of cmn_ref_clk clocks required to wait 2 uSec.
0x2A0 cmn_pll0_varcal_icvf_cfg reset 0x704 — PLL 0 varactor trim calibration integral control voltage configuration register
  [31:16] cmn_pll0_varcal_icvf_cfg_31_16 ro — Reserved
  [15:13] cmn_pll0_varcal_icvf_cfg_15_13 ro — Reserved
  [12] cmn_pll0_varcal_icvf_cfg_12
  [11] cmn_pll0_varcal_icvf_cfg_11 ro — Reserved
  [10:8] cmn_pll0_varcal_icvf_cfg_10_8
  [7] cmn_pll0_varcal_icvf_cfg_7 ro — Reserved
  [6:4] cmn_pll0_varcal_icvf_cfg_6_4
  [3] cmn_pll0_varcal_icvf_cfg_3 ro — Reserved
  [2:0] cmn_pll0_varcal_icvf_cfg_2_0
0x2A4 cmn_pll0_varcal_icvf_lstat — PLL 0 varactor trim calibration integral control voltage low status register
  [31:16] cmn_pll0_varcal_icvf_lstat_31_16 ro — Reserved
  [15:0] cmn_pll0_varcal_icvf_lstat_15_0 ro — Frequency counter result for low frequency measurement
0x2A8 cmn_pll0_varcal_icvf_hstat — PLL 0 varactor trim calibration integral control voltage high status register
  [31:16] cmn_pll0_varcal_icvf_hstat_31_16 ro — Reserved
  [15:0] cmn_pll0_varcal_icvf_hstat_15_0 ro — Frequency counter result for high frequency measurement
0x2AC cmn_pll0_varcal_pllcnt_ovrd — PLL 0 varactor trim calibration PLL clock counter override register
  [31:16] cmn_pll0_varcal_pllcnt_ovrd_31_16 ro — Reserved
  [15:0] cmn_pll0_varcal_pllcnt_ovrd_15_0 — Note that the actual number of clocks counted is one larger than what is specified by this field.
0x300 cmn_pll1_vcocal_ctrl — PLL 1 VCO calibration control register
  [31:16] cmn_pll1_vcocal_ctrl_31_16 ro — Reserved
  [15] cmn_pll1_vcocal_ctrl_15 — Note: This bit is intended to be for diagnostics purposes only. This calibration process is automatically activated internally by the PLL control state machine. When using this bit, the user must wait until after the internally activated process completes.
  [14] cmn_pll1_vcocal_ctrl_14 ro — Note: This bit is not likely to be observed as being set after internal automatic calibration is complete, because the internally generated run signal will be driven inactive immediately after the done signal is activated, and therefore the internal done signal will be cleared.
  [13:8] cmn_pll1_vcocal_ctrl_13_8 ro — Reserved
  [7:0] cmn_pll1_vcocal_ctrl_7_0 ro — Note: The reset value for this field is with the PLL controller power island switched off. In cases where this power island is switched on, the reset value be 8'h28.
0x304 cmn_pll1_vcocal_start reset 0x2064 — PLL 1 VCO calibration start point register
  [31:16] cmn_pll1_vcocal_start_31_16 ro — Reserved
  [15] cmn_pll1_vcocal_start_15 ro — Reserved
  [14:12] cmn_pll1_vcocal_start_14_12 — Note: This field is intended to be for diagnostics purposes only.
  [11:8] cmn_pll1_vcocal_start_11_8 ro — Reserved
  [7:0] cmn_pll1_vcocal_start_7_0 — Note : This field must be set to a value that is always at least one step size away from the minimum and maximum calibration codes, and is a function of the step size specified in this register. For example, if the initial step size is 4, this value must be at least 4 greater than the minimum calibration code or 4 less than the maximum calibration code.
0x308 cmn_pll1_vcocal_tctrl reset 0x3 — PLL 1 VCO calibration timer control register
  [31:16] cmn_pll1_vcocal_tctrl_31_16 ro — Reserved
  [15:3] cmn_pll1_vcocal_tctrl_15_3 ro — Reserved
  [2:0] cmn_pll1_vcocal_tctrl_2_0 — Note: This divider value must not be set to a value so large that not enough feedback clock edges are sampled to make a good decision. There is no good formula for calculating this constraint. The reduced reference period and expected number of feedback clock edges must be calculated and an analysis per- formed as to if enough edges are available in the reduced time.
0x30C cmn_pll1_vcocal_ovrd — PLL 1 VCO calibration override register
  [31:16] cmn_pll1_vcocal_ovrd_31_16 ro — Reserved
  [15] cmn_pll1_vcocal_ovrd_15 — Note: This bit should not be activated while a calibration is currently in progress.
  [14:8] cmn_pll1_vcocal_ovrd_14_8 ro — Reserved
  [7:0] cmn_pll1_vcocal_ovrd_7_0
0x310 cmn_pll1_vcocal_init_tmr reset 0x3E8 — PLL 1 VCO calibration initialization timer register
  [31:16] cmn_pll1_vcocal_init_tmr_31_16 ro — Reserved
  [15:14] cmn_pll1_vcocal_init_tmr_15_14 ro — Reserved
  [13:0] cmn_pll1_vcocal_init_tmr_13_0
0x314 cmn_pll1_vcocal_iter_tmr reset 0x10 — PLL 1 VCO calibration iteration timer register
  [31:16] cmn_pll1_vcocal_iter_tmr_31_16 ro — Reserved
  [15:14] cmn_pll1_vcocal_iter_tmr_15_14 ro — Reserved
  [13:0] cmn_pll1_vcocal_iter_tmr_13_0 — Iteration wait timer value
0x318 cmn_pll1_vcocal_reftim_start reset 0xC5E — PLL 1 VCO calibration reference clock timer start value register
  [31:16] cmn_pll1_vcocal_reftim_start_31_16 ro — Reserved
  [15:14] cmn_pll1_vcocal_reftim_start_15_14 ro — Reserved
  [13:0] cmn_pll1_vcocal_reftim_start_13_0 — Note that the actual number of clocks counted is one larger than what is specified by this field.
0x340 cmn_pll1_intdiv — PLL 1 feedback divider integer register
  [31:16] cmn_pll1_intdiv_31_16 ro — Reserved
  [15:10] cmn_pll1_intdiv_15_10 ro — Reserved
  [9:0] cmn_pll1_intdiv_9_0 — pll_fb_div_integer value
0x344 cmn_pll1_fracdivl — PLL 1 feedback divider fractional low register
  [31:16] cmn_pll1_fracdivl_31_16 ro — Reserved
  [15:0] cmn_pll1_fracdivl_15_0 — pll_fb_div_fractional
0x348 cmn_pll1_fracdivh — PLL 1 feedback divider fractional high register
  [31:16] cmn_pll1_fracdivh_31_16 ro — Reserved
  [15:3] cmn_pll1_fracdivh_15_3 ro — Reserved
  [2:0] cmn_pll1_fracdivh_2_0 — pll_fb_div_fractional
0x34C cmn_pll1_high_thr — PLL 1 feedback divider high threshold register
  [31:16] cmn_pll1_high_thr_31_16 ro — Reserved
  [15:10] cmn_pll1_high_thr_15_10 ro — Reserved
  [9:0] cmn_pll1_high_thr_9_0
0x350 cmn_pll1_dsm_diag reset 0x4004 — PLL 1 delta sigma modulator diagnostics register
  [31:16] cmn_pll1_dsm_diag_31_16 ro — Reserved
  [15] cmn_pll1_dsm_diag_15
  [14] cmn_pll1_dsm_diag_14 — PLL feedback divider override enable
  [13:4] cmn_pll1_dsm_diag_13_4 ro — Reserved
  [3:0] cmn_pll1_dsm_diag_3_0 — PLL feedback divider latency adjustment
0x354 cmn_pll1_dsm_fbh_ovrd reset 0x40 — PLL 1 delta sigma modulator feedback divider value high override register
  [31:16] cmn_pll1_dsm_fbh_ovrd_31_16 ro — Reserved
  [15:10] cmn_pll1_dsm_fbh_ovrd_15_10 ro — Reserved
  [9:0] cmn_pll1_dsm_fbh_ovrd_9_0
0x358 cmn_pll1_dsm_fbl_ovrd reset 0x1C — PLL 1 delta sigma modulator feedback divider value low override register
  [31:16] cmn_pll1_dsm_fbl_ovrd_31_16 ro — Reserved
  [15:10] cmn_pll1_dsm_fbl_ovrd_15_10 ro — Reserved
  [9:0] cmn_pll1_dsm_fbl_ovrd_9_0
0x360 cmn_pll1_ss_ctrl1 reset 0x2 — PLL 1 spread spectrum control register 1
  [31] cmn_pll1_ss_ctrl1_31 ro — Reserved
  [30:16] cmn_pll1_ss_ctrl1_30_16 — Amplitude step size
  [15] cmn_pll1_ss_ctrl1_15 ro — Reserved
  [14:8] cmn_pll1_ss_ctrl1_14_8 — Time step size
  [7:2] cmn_pll1_ss_ctrl1_7_2 ro — Reserved
  [1] cmn_pll1_ss_ctrl1_1 — Spread spectrum waveform generator disable
  [0] cmn_pll1_ss_ctrl1_0 — Spread spectrum enable during VCO calibration
0x364 cmn_pll1_ss_ctrl2 — PLL 1 spread spectrum control register 2
  [31:16] cmn_pll1_ss_ctrl2_31_16 ro — Reserved
  [15] cmn_pll1_ss_ctrl2_15 ro — Reserved
  [14:8] cmn_pll1_ss_ctrl2_14_8 — Note: This field should not be set to 0 when spread spectrum is enabled.
  [7] cmn_pll1_ss_ctrl2_7 ro — Reserved
  [6:0] cmn_pll1_ss_ctrl2_6_0 — Number of steps
0x368 cmn_pll1_ss_ctrl3 — PLL 1 spread spectrum control register 3
  [31:19] cmn_pll1_ss_ctrl3_31_19 ro — Reserved
  [18:0] cmn_pll1_ss_ctrl3_18_0 — Note: The value of this signal must be equal to spread spectrum wave starting step number * amplitude step size.
0x400 cmn_txpucal_ctrl — TX pull up resistor calibration control register
  [31:16] cmn_txpucal_ctrl_31_16 ro — Reserved
  [15] cmn_txpucal_ctrl_15 — Note: This signal is intended to be for diagnostics purposes only. This calibration process is automatically activated internally by the startup state machine. When using this bit, the user must wait until after the internally activated process completes.
  [14] cmn_txpucal_ctrl_14 ro — Note: Three cmn_ref_clk cycles are required after the start of the resistor calibration process to clear this signal.
  [13] cmn_txpucal_ctrl_13 ro — Note: Due to the nature of the calibration process, it is not possible to determine if the analog responded or not for the lowest code of 6'b000000. The reason for this is, when sequencing to lower codes, the calibration function is looking for the analog response to transition from 1'b1 to 1'b0. If the lowest calibration code is the correct code, the analog will respond with 1'b1, and the algorithm can't sequence to a lower code to look for the transition from 1'b1 to 1'b0. Similarly, if the analog is not responding, it is not possible to sequence to a lower code to detect this. Therefore, even when the calibration function selects this calibration code as valid, this bit will be set.
  [12] cmn_txpucal_ctrl_12 ro — Current analog comparator response
  [11:6] cmn_txpucal_ctrl_11_6 ro — Reserved
  [5:0] cmn_txpucal_ctrl_5_0 ro — Note that the most significant bit is the calibration code sign bit, and is always 1'b0 in this application. Note: The reset value for this field is with the common calibration power island switched off. In cases where this power island is switched on, the reset value be 6'b010000.
0x404 cmn_txpucal_ovrd — TX pull up resistor calibration override register
  [31:16] cmn_txpucal_ovrd_31_16 ro — Reserved
  [15] cmn_txpucal_ovrd_15
  [14] cmn_txpucal_ovrd_14
  [13:6] cmn_txpucal_ovrd_13_6 ro — Reserved
  [5:0] cmn_txpucal_ovrd_5_0
0x408 cmn_txpucal_start reset 0x10 — TX pull up resistor calibration start register
  [31:16] cmn_txpucal_start_31_16 ro — Reserved
  [15] cmn_txpucal_start_15
  [14:6] cmn_txpucal_start_14_6 ro — Reserved
  [5:0] cmn_txpucal_start_5_0 — Note that the most significant bit is the calibration code sign bit, and is always 1'b0 in this application.
0x40C cmn_txpucal_tune — TX pull up resistor calibration tune register
  [31:16] cmn_txpucal_tune_31_16 ro — Reserved
  [15:6] cmn_txpucal_tune_15_6 ro — Reserved
  [5:0] cmn_txpucal_tune_5_0 — Note: This value is a twos complement value, so the calibrated code can be increased or decreased.
0x410 cmn_txpucal_init_tmr reset 0x20 — TX pull up resistor calibration initialization timer register
  [31:16] cmn_txpucal_init_tmr_31_16 ro — Reserved
  [15:7] cmn_txpucal_init_tmr_15_7 ro — Reserved
  [6:0] cmn_txpucal_init_tmr_6_0 — Note: This field should never be set to a value of less than 1.
0x414 cmn_txpucal_iter_tmr reset 0x10 — TX pull up resistor calibration iteration timer register
  [31:16] cmn_txpucal_iter_tmr_31_16 ro — Reserved
  [15:7] cmn_txpucal_iter_tmr_15_7 ro — Reserved
  [6:0] cmn_txpucal_iter_tmr_6_0
0x420 cmn_txpdcal_ctrl — TX pull down resistor calibration control register
  [31:16] cmn_txpdcal_ctrl_31_16 ro — Reserved
  [15] cmn_txpdcal_ctrl_15 — Note: This signal is intended to be for diagnostics purposes only. This calibration process is automatically activated internally by the startup state machine. When using this bit, the user must wait until after the internally activated process completes.
  [14] cmn_txpdcal_ctrl_14 ro — Note: Three cmn_ref_clk cycles are required after the start of the resistor calibration process to clear this signal.
  [13] cmn_txpdcal_ctrl_13 ro — Note: Due to the nature of the calibration process, it is not possible to determine if the analog responded or not for the lowest code of 6'b000000. The reason for this is, when sequencing to lower codes, the calibration function is looking for the analog response to transition from 1'b1 to 1'b0. If the lowest calibration code is the correct code, the analog will respond with 1'b1, and the algorithm can't sequence to a lower code to look for the transition from 1'b1 to 1'b0. Similarly, if the analog is not responding, it is not possible to sequence to a lower code to detect this. Therefore, even when the calibration function selects this calibration code as valid, this bit will be set.
  [12] cmn_txpdcal_ctrl_12 ro — Current analog comparator response: This is the current state of the analog comparator response signal (cmnda_rescal_comp_tx). This signal is not synchronized, and is provided for diagnostic purposes only.
  [11:6] cmn_txpdcal_ctrl_11_6 ro — Reserved
  [5:0] cmn_txpdcal_ctrl_5_0 ro — Note that the most significant bit is the calibration code sign bit, and is always 1'b0 in this application. Note: The reset value for this field is with the common calibration power island switched off. In cases where this power island is switched on, the reset value be 6'b010000.
0x424 cmn_txpdcal_ovrd — TX pull down resistor calibration override register
  [31:16] cmn_txpdcal_ovrd_31_16 ro — Reserved
  [15] cmn_txpdcal_ovrd_15 — Note: The value of this field must not be changed while the calibration function is running.
  [14] cmn_txpdcal_ovrd_14 — Note: The value of this field must not be changed while the calibration function is running.
  [13:6] cmn_txpdcal_ovrd_13_6 ro — Reserved
  [5:0] cmn_txpdcal_ovrd_5_0 — Note: The most significant bit is the calibration code sign bit, and is always 1'b0 in this application. Note: The value of this field must not be changed while the calibration function is running.
0x428 cmn_txpdcal_start reset 0x10 — TX pull down resistor calibration start register
  [31:16] cmn_txpdcal_start_31_16 ro — Reserved
  [15] cmn_txpdcal_start_15
  [14:6] cmn_txpdcal_start_14_6 ro — Reserved
  [5:0] cmn_txpdcal_start_5_0 — Note that the most significant bit is the calibration code sign bit, and is always 1'b0 in this application.
0x42C cmn_txpdcal_tune — TX pull down resistor calibration tune register
  [31:16] cmn_txpdcal_tune_31_16 ro — Reserved
  [15:6] cmn_txpdcal_tune_15_6 ro — Reserved
  [5:0] cmn_txpdcal_tune_5_0 — Note: This value is a twos complement value, so the calibrated code can be increased or decreased.
0x430 cmn_txpdcal_init_tmr reset 0x20 — TX pull down resistor calibration initialization timer register
  [31:16] cmn_txpdcal_init_tmr_31_16 ro — Reserved
  [15:7] cmn_txpdcal_init_tmr_15_7 ro — Reserved
  [6:0] cmn_txpdcal_init_tmr_6_0 — Note: This field should never be set to a value of less than 1.
0x434 cmn_txpdcal_iter_tmr reset 0x10 — TX pull down resistor calibration iteration timer register
  [31:16] cmn_txpdcal_iter_tmr_31_16 ro — Reserved
  [15:7] cmn_txpdcal_iter_tmr_15_7 ro — Reserved
  [6:0] cmn_txpdcal_iter_tmr_6_0
0x440 cmn_rxcal_ctrl — RX resistor calibration control register
  [31:16] cmn_rxcal_ctrl_31_16 ro — Reserved
  [15] cmn_rxcal_ctrl_15 — Note: This signal is intended to be for diagnostics purposes only. This calibration process is automatically activated internally by the startup state machine. When using this bit, the user must wait until after the internally activated process completes.
  [14] cmn_rxcal_ctrl_14 ro — Note: Three cmn_ref_clk cycles are required after the start of the resistor calibration process to clear this signal.
  [13] cmn_rxcal_ctrl_13 ro — Note: Due to the nature of the calibration process, it is not possible to determine if the analog responded or not for the lowest code of 5'b00000. The reason for this is, when sequencing to lower codes, the calibration function is looking for the analog response to transition from 1'b1 to 1'b0. If the lowest calibration code is the correct code, the analog will respond with 1'b1, and the algorithm can't sequence to a lower code to look for the transition from 1'b1 to 1'b0. Similarly, if the analog is not responding, it is not possible to sequence to a lower code to detect this. Therefore, even when the calibration function selects this calibration code as valid, this bit will be set.
  [12] cmn_rxcal_ctrl_12 ro — Current analog comparator response
  [11:6] cmn_rxcal_ctrl_11_6 ro — Reserved
  [5:0] cmn_rxcal_ctrl_5_0 ro — Note that the most significant bit is the calibration code sign bit, and is always 1'b0 in this application.
0x444 cmn_rxcal_ovrd — RX resistor calibration override register
  [31:16] cmn_rxcal_ovrd_31_16 ro — Reserved
  [15] cmn_rxcal_ovrd_15
  [14] cmn_rxcal_ovrd_14
  [13:6] cmn_rxcal_ovrd_13_6 ro — Reserved
  [5:0] cmn_rxcal_ovrd_5_0
0x448 cmn_rxcal_start reset 0x10 — RX resistor calibration start register
  [31:16] cmn_rxcal_start_31_16 ro — Reserved
  [15] cmn_rxcal_start_15
  [14:6] cmn_rxcal_start_14_6 ro — Reserved
  [5:0] cmn_rxcal_start_5_0
0x44C cmn_rxcal_tune — RX resistor calibration tune register
  [31:16] cmn_rxcal_tune_31_16 ro — Reserved
  [15:6] cmn_rxcal_tune_15_6 ro — Reserved
  [5:0] cmn_rxcal_tune_5_0 — Note: This value is a twos complement value, so the calibrated code can be increased or decreased.
0x450 cmn_rxcal_init_tmr reset 0x2F0 — RX resistor calibration initialization timer register
  [31:16] cmn_rxcal_init_tmr_31_16 ro — Reserved
  [15:12] cmn_rxcal_init_tmr_15_12 ro — Reserved
  [11:0] cmn_rxcal_init_tmr_11_0 — Note: This field should never be set to a value of less than 1.
0x454 cmn_rxcal_iter_tmr reset 0x10 — RX resistor calibration iteration timer register
  [31:16] cmn_rxcal_iter_tmr_31_16 ro — Reserved
  [15:12] cmn_rxcal_iter_tmr_15_12 ro — Reserved
  [11:0] cmn_rxcal_iter_tmr_11_0
0x480 cmn_sd_cal_ctrl — Signal detect clock calibration control register
  [31:16] cmn_sd_cal_ctrl_31_16 ro — Reserved
  [15] cmn_sd_cal_ctrl_15 — Note: This bit is intended to be for diagnostics purposes only. This calibration process is automatically activated internally by the startup state machine. When using this bit, the user must wait until after the internally activated process completes.
  [14] cmn_sd_cal_ctrl_14 ro — Note: This bit is not likely to be observed as being set after internal automatic calibration is complete, because the internally generated run signal will be driven inactive immediately after the done signal is activated, and therefore the internal done signal will be cleared.
  [13:5] cmn_sd_cal_ctrl_13_5 ro — Reserved
  [4:0] cmn_sd_cal_ctrl_4_0 ro — Note: The reset value for this field is with the common calibration power island switched off. In cases where this power island is switched on, the reset value be 5'b11110
0x484 cmn_sd_cal_start reset 0x101E — Signal detect clock calibration start point register
  [31:16] cmn_sd_cal_start_31_16 ro — Reserved
  [15] cmn_sd_cal_start_15 ro — Reserved
  [14:12] cmn_sd_cal_start_14_12
  [11:5] cmn_sd_cal_start_11_5 ro — Reserved
  [4:0] cmn_sd_cal_start_4_0 — Note: The reset value for this field is with the common calibration power island switched off. In cases where this power island is switched on, the reset value be 5'b11110
0x488 cmn_sd_cal_tctrl reset 0x1 — Signal detect clock calibration timer control register
  [31:16] cmn_sd_cal_tctrl_31_16 ro — Reserved
  [15:3] cmn_sd_cal_tctrl_15_3 ro — Reserved
  [2:0] cmn_sd_cal_tctrl_2_0 — Note: This divider value must not be set to a value so large that not enough feedback clock edges are sampled to make a good decision. There is no good formula for calculating this constraint. The reduced reference period and expected number of feedback clock edges must be calculated and an analysis performed as to if enough edges are available in the reduced time.
0x48C cmn_sd_cal_ovrd — Signal detect clock calibration override register
  [31:16] cmn_sd_cal_ovrd_31_16 ro — Reserved
  [15] cmn_sd_cal_ovrd_15 — Note: The value of this field must not be changed while the calibration function is running.
  [14:5] cmn_sd_cal_ovrd_14_5 ro — Reserved
  [4:0] cmn_sd_cal_ovrd_4_0 — Note: The value of this field must not be changed while the calibration function is running.
0x490 cmn_sd_cal_init_tmr reset 0x6 — Signal detect clock calibration initialization timer register
  [31:16] cmn_sd_cal_init_tmr_31_16 ro — Reserved
  [15:8] cmn_sd_cal_init_tmr_15_8 ro — Reserved
  [7:0] cmn_sd_cal_init_tmr_7_0 — Cadence internal note: The additional four clocks were added as margin. Early in the design process, it was thought that the signal detect calibration clock could take a few clock cycles to start, then additional clocks to get through the data sync associated with the its clock gating cell. In reality this is likely not necessary, but we are leaving it in, since it is a very small number of clocks.
0x494 cmn_sd_cal_iter_tmr reset 0x2 — Signal detect clock calibration iteration timer register
  [31:16] cmn_sd_cal_iter_tmr_31_16 ro — Reserved
  [15:8] cmn_sd_cal_iter_tmr_15_8 ro — Reserved
  [7:0] cmn_sd_cal_iter_tmr_7_0 — Note: This results in the minimum number of cmn_ref_clk clocks required to wait 80 nSec.
0x498 cmn_sd_cal_reftim_start reset 0xE — Signal detect clock calibration reference clock timer start value register
  [31:16] cmn_sd_cal_reftim_start_31_16 ro — Reserved
  [15:8] cmn_sd_cal_reftim_start_15_8 ro — Reserved
  [7:0] cmn_sd_cal_reftim_start_7_0 — Note that the actual number of clocks counted is one larger than what is specified by this field.
0x4A0 cmn_sd_cal_pllcnt_start reset 0x12B — Signal detect clock calibration PLL clock counter start value register
  [31:16] cmn_sd_cal_pllcnt_start_31_16 ro — Reserved
  [15:10] cmn_sd_cal_pllcnt_start_15_10 ro — Reserved
  [9:0] cmn_sd_cal_pllcnt_start_9_0 — Note that the actual number of clocks counted is one larger than what is specified by this field.
0x580 cmn_cmsmt_clk_freq_msmt_ctrl — Clock frequency measurement control register
  [31:16] cmn_cmsmt_clk_freq_msmt_ctrl_31_16 ro — Reserved
  [15] cmn_cmsmt_clk_freq_msmt_ctrl_15 — Note: The values in the Test clock selection register and Reference clock timer value register must be set prior to activating this bit.
  [14] cmn_cmsmt_clk_freq_msmt_ctrl_14 ro — Test clock measurement done
  [13:0] cmn_cmsmt_clk_freq_msmt_ctrl_13_0 ro — Reserved
0x584 cmn_cmsmt_test_clk_sel — Test clock selection register
  [31:16] cmn_cmsmt_test_clk_sel_31_16 ro — Reserved
  [15:4] cmn_cmsmt_test_clk_sel_15_4 ro — Reserved
  [3:0] cmn_cmsmt_test_clk_sel_3_0
0x588 cmn_cmsmt_ref_clk_tmr_value — Reference clock timer value register
  [31:16] cmn_cmsmt_ref_clk_tmr_value_31_16 ro — Reserved
  [15:0] cmn_cmsmt_ref_clk_tmr_value_15_0
0x58C cmn_cmsmt_test_clk_cnt_value — Test clock counter value register
  [31:16] cmn_cmsmt_test_clk_cnt_value_31_16 ro — Reserved
  [15:0] cmn_cmsmt_test_clk_cnt_value_15_0 ro — Test clock counter value: When the test clock measurement process is complete, the value in this field specifies the number of test clock cycles that were counted in the time specified by the reference clock timer value. This field is only valid while the test clock measurement done bit in the Clock frequency measurement control register is active.
0x680 cmn_pdiag_pll0_ctrl_m0 reset 0x4031 — PLL 0 control register mode 0
  [31:16] cmn_pdiag_pll0_ctrl_m0_31_16 ro — Reserved
  [15] cmn_pdiag_pll0_ctrl_m0_15 ro — Reserved
  [14] cmn_pdiag_pll0_ctrl_m0_14
  [13] cmn_pdiag_pll0_ctrl_m0_13
  [12] cmn_pdiag_pll0_ctrl_m0_12 — Cadence note: The DSM must be enabled because this function requires the DSM clock to be running.
  [11:10] cmn_pdiag_pll0_ctrl_m0_11_10 ro — Reserved
  [9] cmn_pdiag_pll0_ctrl_m0_9 — PLL VCO calibration enable override enable:
  [8] cmn_pdiag_pll0_ctrl_m0_8 — PLL VCO calibration enable override:
  [7] cmn_pdiag_pll0_ctrl_m0_7 ro — Reserved
  [6] cmn_pdiag_pll0_ctrl_m0_6
  [5] cmn_pdiag_pll0_ctrl_m0_5
  [4] cmn_pdiag_pll0_ctrl_m0_4
  [3:2] cmn_pdiag_pll0_ctrl_m0_3_2 ro — Reserved
  [1:0] cmn_pdiag_pll0_ctrl_m0_1_0
0x684 cmn_pdiag_pll0_tune_m0 reset 0x2400020F — PLL 0 tune register mode 0
  [31:30] cmn_pdiag_pll0_tune_m0_31_30 ro — Reserved
  [29:28] cmn_pdiag_pll0_tune_m0_29_28
  [27] cmn_pdiag_pll0_tune_m0_27 ro — Reserved
  [26:24] cmn_pdiag_pll0_tune_m0_26_24
  [23:18] cmn_pdiag_pll0_tune_m0_23_18 ro — Reserved
  [17] cmn_pdiag_pll0_tune_m0_17 ro — Reserved
  [16] cmn_pdiag_pll0_tune_m0_16
  [15] cmn_pdiag_pll0_tune_m0_15
  [14] cmn_pdiag_pll0_tune_m0_14 ro — Reserved
  [13] cmn_pdiag_pll0_tune_m0_13
  [12] cmn_pdiag_pll0_tune_m0_12
  [11:10] cmn_pdiag_pll0_tune_m0_11_10 ro — Reserved
  [9:8] cmn_pdiag_pll0_tune_m0_9_8
  [7:0] cmn_pdiag_pll0_tune_m0_7_0 — Note: This field is required to be thermometer encoded, as shown below.
0x688 cmn_pdiag_pll0_pkvco_bw_ctrl_m0 — PLL 0 proportional KVCO bandwidth control register mode 0
  [31:16] cmn_pdiag_pll0_pkvco_bw_ctrl_m0_31_16 ro — Reserved
  [15:5] cmn_pdiag_pll0_pkvco_bw_ctrl_m0_15_5 ro — Reserved
  [4] cmn_pdiag_pll0_pkvco_bw_ctrl_m0_4
  [3:2] cmn_pdiag_pll0_pkvco_bw_ctrl_m0_3_2 ro — Reserved
  [1:0] cmn_pdiag_pll0_pkvco_bw_ctrl_m0_1_0
0x68C cmn_pdiag_pll0_cp_padj_m0 reset 0x290 — PLL 0 charge pump proportional path adjust register mode 0
  [31:13] cmn_pdiag_pll0_cp_padj_m0_31_13 ro — Reserved
  [12:8] cmn_pdiag_pll0_cp_padj_m0_12_8 — Valid values for this field range from [0-31].
  [7:0] cmn_pdiag_pll0_cp_padj_m0_7_0 — PLL charge pump proportional path current adjust
0x690 cmn_pdiag_pll0_cp_iadj_m0 reset 0xC14 — PLL 0 charge pump integral path adjust register mode 0
  [31:12] cmn_pdiag_pll0_cp_iadj_m0_31_12 ro — Reserved
  [11:8] cmn_pdiag_pll0_cp_iadj_m0_11_8 — Valid values for this field range from [0-15].
  [7:5] cmn_pdiag_pll0_cp_iadj_m0_7_5 ro — Reserved
  [4:0] cmn_pdiag_pll0_cp_iadj_m0_4_0
0x694 cmn_pdiag_pll0_filt_padj_m0 — PLL 0 proportional path filter adjust register mode 0
  [31:17] cmn_pdiag_pll0_filt_padj_m0_31_17 ro — Reserved
  [16] cmn_pdiag_pll0_filt_padj_m0_16
  [15:13] cmn_pdiag_pll0_filt_padj_m0_15_13 ro — Reserved
  [12:8] cmn_pdiag_pll0_filt_padj_m0_12_8 — PLL proportional path filter capacitance adjust
  [7:4] cmn_pdiag_pll0_filt_padj_m0_7_4 ro — Reserved
  [3:0] cmn_pdiag_pll0_filt_padj_m0_3_0
0x698 cmn_pdiag_pll0_prog0_clk_ctrl_m0 reset 0x4040001 — PLL 0 programmable clock 0 control register mode 0
  [31] cmn_pdiag_pll0_prog0_clk_ctrl_m0_31 ro — Reserved
  [30:24] cmn_pdiag_pll0_prog0_clk_ctrl_m0_30_24 — PLL 0 programmable clock 0 divider integer low value (div int low):
  [23] cmn_pdiag_pll0_prog0_clk_ctrl_m0_23 ro — Reserved
  [22:16] cmn_pdiag_pll0_prog0_clk_ctrl_m0_22_16 — Note: The value of this field must be an even number.
  [15:12] cmn_pdiag_pll0_prog0_clk_ctrl_m0_15_12 ro — Reserved
  [11:8] cmn_pdiag_pll0_prog0_clk_ctrl_m0_11_8 — Note: When the divider is in fractional mode 0, the maximum field this signal can be is 4'h7 (7) and when the divider is in fractional mode 1, the maximum value this field can be is 4'h7 (7).
  [7:2] cmn_pdiag_pll0_prog0_clk_ctrl_m0_7_2 ro — Reserved
  [1] cmn_pdiag_pll0_prog0_clk_ctrl_m0_1
  [0] cmn_pdiag_pll0_prog0_clk_ctrl_m0_0
0x69C cmn_pdiag_pll0_prog1_clk_ctrl_m0 — PLL 0 programmable clock 1 control register mode 0
  [31] cmn_pdiag_pll0_prog1_clk_ctrl_m0_31 ro — Reserved
  [30:24] cmn_pdiag_pll0_prog1_clk_ctrl_m0_30_24 — PLL 0 programmable clock 1 divider integer low value (div int low):
  [23] cmn_pdiag_pll0_prog1_clk_ctrl_m0_23 ro — Reserved
  [22:16] cmn_pdiag_pll0_prog1_clk_ctrl_m0_22_16 — Note: The value of this field must be an even number.
  [15:12] cmn_pdiag_pll0_prog1_clk_ctrl_m0_15_12 ro — Reserved
  [11:8] cmn_pdiag_pll0_prog1_clk_ctrl_m0_11_8 — Note: When the divider is in fractional mode 0, the maximum field this signal can be is 4'h7 (7) and when the divider is in fractional mode 1, the maximum value this field can be is 4'h7 (7).
  [7:2] cmn_pdiag_pll0_prog1_clk_ctrl_m0_7_2 ro — Reserved
  [1] cmn_pdiag_pll0_prog1_clk_ctrl_m0_1
  [0] cmn_pdiag_pll0_prog1_clk_ctrl_m0_0
0x6A0 cmn_pdiag_pll0_post_div_m0 — PLL 0 post divide register mode 0
  [31:1] cmn_pdiag_pll0_post_div_m0_31_1 ro — Reserved
  [0] cmn_pdiag_pll0_post_div_m0_0
0x6C0 cmn_pdiag_pll0_ctrl_m1 reset 0x31 — PLL 0 control register mode1
  [31:16] cmn_pdiag_pll0_ctrl_m1_31_16 ro — Reserved
  [15] cmn_pdiag_pll0_ctrl_m1_15 ro — Reserved
  [14] cmn_pdiag_pll0_ctrl_m1_14
  [13] cmn_pdiag_pll0_ctrl_m1_13
  [12] cmn_pdiag_pll0_ctrl_m1_12 — Cadence note: The DSM must be enabled because this function requires the DSM clock to be running.
  [11:10] cmn_pdiag_pll0_ctrl_m1_11_10 ro — Reserved
  [9] cmn_pdiag_pll0_ctrl_m1_9 — PLL VCO calibration enable override enable:
  [8] cmn_pdiag_pll0_ctrl_m1_8 — PLL VCO calibration enable override:
  [7] cmn_pdiag_pll0_ctrl_m1_7 ro — Reserved
  [6] cmn_pdiag_pll0_ctrl_m1_6
  [5] cmn_pdiag_pll0_ctrl_m1_5
  [4] cmn_pdiag_pll0_ctrl_m1_4
  [3:2] cmn_pdiag_pll0_ctrl_m1_3_2 ro — Reserved
  [1:0] cmn_pdiag_pll0_ctrl_m1_1_0
0x6C4 cmn_pdiag_pll0_tune_m1 reset 0x2400020F — PLL 0 tune register mode 1
  [31:30] cmn_pdiag_pll0_tune_m1_31_30 ro — Reserved
  [29:28] cmn_pdiag_pll0_tune_m1_29_28
  [27] cmn_pdiag_pll0_tune_m1_27 ro — Reserved
  [26:24] cmn_pdiag_pll0_tune_m1_26_24
  [23:18] cmn_pdiag_pll0_tune_m1_23_18 ro — Reserved
  [17] cmn_pdiag_pll0_tune_m1_17 ro — Reserved
  [16] cmn_pdiag_pll0_tune_m1_16
  [15] cmn_pdiag_pll0_tune_m1_15
  [14] cmn_pdiag_pll0_tune_m1_14 ro — Reserved
  [13] cmn_pdiag_pll0_tune_m1_13
  [12] cmn_pdiag_pll0_tune_m1_12
  [11:10] cmn_pdiag_pll0_tune_m1_11_10 ro — Reserved
  [9:8] cmn_pdiag_pll0_tune_m1_9_8
  [7:0] cmn_pdiag_pll0_tune_m1_7_0 — Note: This field is required to be thermometer encoded, as shown below.
0x6C8 cmn_pdiag_pll0_pkvco_bw_ctrl_m1 — PLL 0 proportional KVCO bandwidth control register mode 1
  [31:16] cmn_pdiag_pll0_pkvco_bw_ctrl_m1_31_16 ro — Reserved
  [15:5] cmn_pdiag_pll0_pkvco_bw_ctrl_m1_15_5 ro — Reserved
  [4] cmn_pdiag_pll0_pkvco_bw_ctrl_m1_4
  [3:2] cmn_pdiag_pll0_pkvco_bw_ctrl_m1_3_2 ro — Reserved
  [1:0] cmn_pdiag_pll0_pkvco_bw_ctrl_m1_1_0
0x6CC cmn_pdiag_pll0_cp_padj_m1 reset 0x1266 — PLL 0 charge pump proportional path adjust register mode 1
  [31:16] cmn_pdiag_pll0_cp_padj_m1_31_16 ro — Reserved
  [15:8] cmn_pdiag_pll0_cp_padj_m1_15_8
  [7:0] cmn_pdiag_pll0_cp_padj_m1_7_0 — PLL charge pump proportional path current adjust
0x6D0 cmn_pdiag_pll0_cp_iadj_m1 reset 0xC10 — PLL 0 charge pump integral path adjust register mode 1
  [31:16] cmn_pdiag_pll0_cp_iadj_m1_31_16 ro — Reserved
  [15:8] cmn_pdiag_pll0_cp_iadj_m1_15_8
  [7:0] cmn_pdiag_pll0_cp_iadj_m1_7_0 — Valid values for this field range from [0-31].
0x6D4 cmn_pdiag_pll0_filt_padj_m1 reset 0xF02 — PLL 0 proportional path filter adjust register mode 1
  [31:17] cmn_pdiag_pll0_filt_padj_m1_31_17 ro — Reserved
  [16] cmn_pdiag_pll0_filt_padj_m1_16
  [15:13] cmn_pdiag_pll0_filt_padj_m1_15_13 ro — Reserved
  [12:8] cmn_pdiag_pll0_filt_padj_m1_12_8 — PLL proportional path filter capacitance adjust:
  [7:4] cmn_pdiag_pll0_filt_padj_m1_7_4 ro — Reserved
  [3:0] cmn_pdiag_pll0_filt_padj_m1_3_0 — PLL proportional path filter resistance adjust:
0x6D8 cmn_pdiag_pll0_prog0_clk_ctrl_m1 reset 0x4040001 — PLL 0 programmable clock 0 control register mode 1
  [31] cmn_pdiag_pll0_prog0_clk_ctrl_m1_31 ro — Reserved
  [30:24] cmn_pdiag_pll0_prog0_clk_ctrl_m1_30_24 — PLL 0 programmable clock 0 divider integer low value (div int low):
  [23] cmn_pdiag_pll0_prog0_clk_ctrl_m1_23 ro — Reserved
  [22:16] cmn_pdiag_pll0_prog0_clk_ctrl_m1_22_16 — Note: The value of this field must be an even number.
  [15:12] cmn_pdiag_pll0_prog0_clk_ctrl_m1_15_12 ro — Reserved
  [11:8] cmn_pdiag_pll0_prog0_clk_ctrl_m1_11_8 — Note: When the divider is in fractional mode 0, the maximum field this signal can be is 4'h7 (7) and when the divider is in fractional mode 1, the maximum value this field can be is 4'h7 (7).
  [7:2] cmn_pdiag_pll0_prog0_clk_ctrl_m1_7_2 ro — Reserved
  [1] cmn_pdiag_pll0_prog0_clk_ctrl_m1_1
  [0] cmn_pdiag_pll0_prog0_clk_ctrl_m1_0
0x6DC cmn_pdiag_pll0_prog1_clk_ctrl_m1 — PLL 0 programmable clock 1 control register mode 1
  [31] cmn_pdiag_pll0_prog1_clk_ctrl_m1_31 ro — Reserved
  [30:24] cmn_pdiag_pll0_prog1_clk_ctrl_m1_30_24 — PLL 0 programmable clock 1 divider integer low value (div int low):
  [23] cmn_pdiag_pll0_prog1_clk_ctrl_m1_23 ro — Reserved
  [22:16] cmn_pdiag_pll0_prog1_clk_ctrl_m1_22_16 — Note: The value of this field must be an even number.
  [15:12] cmn_pdiag_pll0_prog1_clk_ctrl_m1_15_12 ro — Reserved
  [11:8] cmn_pdiag_pll0_prog1_clk_ctrl_m1_11_8 — Note: When the divider is in fractional mode 0, the maximum field this signal can be is 4'h7 (7) and when the divider is in fractional mode 1, the maximum value this field can be is 4'h7 (7).
  [7:2] cmn_pdiag_pll0_prog1_clk_ctrl_m1_7_2 ro — Reserved
  [1] cmn_pdiag_pll0_prog1_clk_ctrl_m1_1
  [0] cmn_pdiag_pll0_prog1_clk_ctrl_m1_0
0x6E0 cmn_pdiag_pll0_post_div_m1 — PLL 0 post divide register mode 1
  [31:1] cmn_pdiag_pll0_post_div_m1_31_1 ro — Reserved
  [0] cmn_pdiag_pll0_post_div_m1_0
0x700 cmn_pdiag_pll1_vreg_adj_m0 — PLL 1 voltage regulator adjust register mode 0
  [31:13] cmn_pdiag_pll1_vreg_adj_m0_31_13 ro — Reserved
  [12:8] cmn_pdiag_pll1_vreg_adj_m0_12_8 — PLL voltage regulator analog adjust
  [7:6] cmn_pdiag_pll1_vreg_adj_m0_7_6 — PLL voltage regulator reference adjust:
  [5:4] cmn_pdiag_pll1_vreg_adj_m0_5_4 — PLL voltage regulator digital selection
  [3:2] cmn_pdiag_pll1_vreg_adj_m0_3_2 — PLL voltage regulator analog selection:
  [1] cmn_pdiag_pll1_vreg_adj_m0_1 — PLL voltage regulator source follower current increase:
  [0] cmn_pdiag_pll1_vreg_adj_m0_0 — PLL voltage regulator vco source follower current increase:
0x704 cmn_pdiag_pll1_pfd_ctrl_m0 — PLL 1 phase frequency detector control register mode 0
  [31:9] cmn_pdiag_pll1_pfd_ctrl_m0_31_9 ro — Reserved
  [8] cmn_pdiag_pll1_pfd_ctrl_m0_8
  [7:5] cmn_pdiag_pll1_pfd_ctrl_m0_7_5 — PLL phase frequency detector pulse width control:
  [4] cmn_pdiag_pll1_pfd_ctrl_m0_4 — PLL up frequency value:
  [3] cmn_pdiag_pll1_pfd_ctrl_m0_3 — PLL down frequency value:
  [2:0] cmn_pdiag_pll1_pfd_ctrl_m0_2_0 — PLL phase frequency detector reset delay control:
0x708 cmn_pdiag_pll1_cp_ctrl_m0 — PLL 1 charge pump control register mode 0
  [31:17] cmn_pdiag_pll1_cp_ctrl_m0_31_17 ro — Reserved
  [16:15] cmn_pdiag_pll1_cp_ctrl_m0_16_15 — PLL charge pump unused pin
  [14:11] cmn_pdiag_pll1_cp_ctrl_m0_14_11 — PLL charge pump selection:
  [10:8] cmn_pdiag_pll1_cp_ctrl_m0_10_8 — PLL charge pump current source control
  [7:2] cmn_pdiag_pll1_cp_ctrl_m0_7_2 — PLL charge pump bias control:
  [1:0] cmn_pdiag_pll1_cp_ctrl_m0_1_0 — PLL charge pump current source positive temperature coefficient ratio
0x70C cmn_pdiag_pll1_lpf_ctrl_m0 — PLL 1 low pass filter control register mode 0
  [31:11] cmn_pdiag_pll1_lpf_ctrl_m0_31_11 ro — Reserved
  [10:6] cmn_pdiag_pll1_lpf_ctrl_m0_10_6 — PLL low pass filter control:
  [5] cmn_pdiag_pll1_lpf_ctrl_m0_5 — PLL low pass filter reset:
  [4:0] cmn_pdiag_pll1_lpf_ctrl_m0_4_0 — PLL low pass filter charge pump control
0x710 cmn_pdiag_pll1_vco_ctrl_m0 reset 0x60000 — PLL 1 voltage-controller oscillator control register mode 0
  [31:20] cmn_pdiag_pll1_vco_ctrl_m0_31_20 ro — Reserved
  [19] cmn_pdiag_pll1_vco_ctrl_m0_19 — The DSM must be enabled because this function requires the DSM clock to be running.
  [18:17] cmn_pdiag_pll1_vco_ctrl_m0_18_17
  [16:12] cmn_pdiag_pll1_vco_ctrl_m0_16_12 — PLL VCO fixed current control
  [11:8] cmn_pdiag_pll1_vco_ctrl_m0_11_8 — PLL VCO filter bandwidth trim
  [7] cmn_pdiag_pll1_vco_ctrl_m0_7 — PLL VCO initialization
  [6:4] cmn_pdiag_pll1_vco_ctrl_m0_6_4 — PLL VCO KVCO control
  [3:0] cmn_pdiag_pll1_vco_ctrl_m0_3_0 — PLL VCO voltage control initialization trim one hot:
0x714 cmn_pdiag_pll1_lock_det_ctrl_m0 — PLL 1 lock detect control register mode 0
  [31:6] cmn_pdiag_pll1_lock_det_ctrl_m0_31_6 ro — Reserved
  [5:0] cmn_pdiag_pll1_lock_det_ctrl_m0_5_0 — PLL lock detection depth control:
0x718 cmn_pdiag_pll1_post_div_m0 — PLL 1 post divide register mode 0
  [31:3] cmn_pdiag_pll1_post_div_m0_31_3 ro — Reserved
  [2:0] cmn_pdiag_pll1_post_div_m0_2_0
0x71C cmn_pdiag_pll1_ref_clk_div_sel_m0 — PLL 1 reference clock divide selection register mode 0
  [31:6] cmn_pdiag_pll1_ref_clk_div_sel_m0_31_6 ro — Reserved
  [5:0] cmn_pdiag_pll1_ref_clk_div_sel_m0_5_0 — PLL reference clock divide selection:
0x720 cmn_pdiag_pll1_prog0_clk_ctrl_m0 — PLL 1 programmable clock 0 control register mode 0
  [31] cmn_pdiag_pll1_prog0_clk_ctrl_m0_31 ro — Reserved
  [30:24] cmn_pdiag_pll1_prog0_clk_ctrl_m0_30_24 — PLL 1 programmable clock 0 divider integer low value (div int low):
  [23] cmn_pdiag_pll1_prog0_clk_ctrl_m0_23 ro — Reserved
  [22:16] cmn_pdiag_pll1_prog0_clk_ctrl_m0_22_16 — Note: The value of this field must be an even number.
  [15:12] cmn_pdiag_pll1_prog0_clk_ctrl_m0_15_12 ro — Reserved
  [11:8] cmn_pdiag_pll1_prog0_clk_ctrl_m0_11_8 — See the register description above for details about how this field is used to specify the divide ratio. Note: When the divider is in fractional mode 0, the maximum field this signal can be is 4'h7 (7) and when the divider is in fractional mode 1, the maximum value this field can be is 4'h7 (7).
  [7:3] cmn_pdiag_pll1_prog0_clk_ctrl_m0_7_3 ro — Reserved
  [2] cmn_pdiag_pll1_prog0_clk_ctrl_m0_2
  [1] cmn_pdiag_pll1_prog0_clk_ctrl_m0_1
  [0] cmn_pdiag_pll1_prog0_clk_ctrl_m0_0
0x724 cmn_pdiag_pll1_prog1_clk_ctrl_m0 — PLL 1 programmable clock 1 control register mode 0
  [31] cmn_pdiag_pll1_prog1_clk_ctrl_m0_31 ro — Reserved
  [30:24] cmn_pdiag_pll1_prog1_clk_ctrl_m0_30_24 — PLL 1 programmable clock 1 divider integer low value (div int low):
  [23] cmn_pdiag_pll1_prog1_clk_ctrl_m0_23 ro — Reserved
  [22:16] cmn_pdiag_pll1_prog1_clk_ctrl_m0_22_16 — Note: The value of this field must be an even number.
  [15:12] cmn_pdiag_pll1_prog1_clk_ctrl_m0_15_12 ro — Reserved
  [11:8] cmn_pdiag_pll1_prog1_clk_ctrl_m0_11_8 — Note: When the divider is in fractional mode 0, the maximum field this signal can be is 4'h7 (7) and when the divider is in fractional mode 1, the maximum value this field can be is 4'h7 (7).
  [7:3] cmn_pdiag_pll1_prog1_clk_ctrl_m0_7_3 ro — Reserved
  [2] cmn_pdiag_pll1_prog1_clk_ctrl_m0_2
  [1] cmn_pdiag_pll1_prog1_clk_ctrl_m0_1
  [0] cmn_pdiag_pll1_prog1_clk_ctrl_m0_0
0x740 cmn_pdiag_pll1_vreg_adj_m1 — PLL 1 voltage regulator adjust register mode 1
  [31:13] cmn_pdiag_pll1_vreg_adj_m1_31_13 ro — Reserved
  [12:8] cmn_pdiag_pll1_vreg_adj_m1_12_8 — PLL voltage regulator analog adjust
  [7:6] cmn_pdiag_pll1_vreg_adj_m1_7_6 — PLL voltage regulator reference adjust:
  [5:4] cmn_pdiag_pll1_vreg_adj_m1_5_4 — PLL voltage regulator digital selection
  [3:2] cmn_pdiag_pll1_vreg_adj_m1_3_2 — PLL voltage regulator analog selection:
  [1] cmn_pdiag_pll1_vreg_adj_m1_1 — PLL voltage regulator source follower current increase:
  [0] cmn_pdiag_pll1_vreg_adj_m1_0 — PLL voltage regulator vco source follower current increase:
0x744 cmn_pdiag_pll1_pfd_ctrl_m1 — PLL 1 phase frequency detector control register mode 1
  [31:9] cmn_pdiag_pll1_pfd_ctrl_m1_31_9 ro — Reserved
  [8] cmn_pdiag_pll1_pfd_ctrl_m1_8
  [7:5] cmn_pdiag_pll1_pfd_ctrl_m1_7_5 — PLL phase frequency detector pulse width control:
  [4] cmn_pdiag_pll1_pfd_ctrl_m1_4 — PLL up frequency value:
  [3] cmn_pdiag_pll1_pfd_ctrl_m1_3 — PLL down frequency value:
  [2:0] cmn_pdiag_pll1_pfd_ctrl_m1_2_0 — PLL phase frequency detector reset delay control:
0x748 cmn_pdiag_pll1_cp_ctrl_m1 — PLL 1 charge pump control register mode 1
  [31:17] cmn_pdiag_pll1_cp_ctrl_m1_31_17 ro — Reserved
  [16:15] cmn_pdiag_pll1_cp_ctrl_m1_16_15 — PLL reserved pin
  [14:11] cmn_pdiag_pll1_cp_ctrl_m1_14_11 — PLL charge pump selection:
  [10:8] cmn_pdiag_pll1_cp_ctrl_m1_10_8 — PLL charge pump current source control
  [7:2] cmn_pdiag_pll1_cp_ctrl_m1_7_2 — PLL charge pump bias control:
  [1:0] cmn_pdiag_pll1_cp_ctrl_m1_1_0 — PLL charge pump current source positive temperature coefficient ratio
0x74C cmn_pdiag_pll1_lpf_ctrl_m1 — PLL 1 low pass filter control register mode 1
  [31:11] cmn_pdiag_pll1_lpf_ctrl_m1_31_11 ro — Reserved
  [10:6] cmn_pdiag_pll1_lpf_ctrl_m1_10_6 — PLL low pass filter control:
  [5] cmn_pdiag_pll1_lpf_ctrl_m1_5 — PLL low pass filter reset:
  [4:0] cmn_pdiag_pll1_lpf_ctrl_m1_4_0 — PLL low pass filter charge pump control
0x750 cmn_pdiag_pll1_vco_ctrl_m1 reset 0x60000 — PLL 1 voltage-controller oscillator control register mode 1
  [31:20] cmn_pdiag_pll1_vco_ctrl_m1_31_20 ro — Reserved
  [19] cmn_pdiag_pll1_vco_ctrl_m1_19 — The DSM must be enabled because this function requires the DSM clock to be running.
  [18:17] cmn_pdiag_pll1_vco_ctrl_m1_18_17
  [16:12] cmn_pdiag_pll1_vco_ctrl_m1_16_12 — PLL VCO fixed current control
  [11:8] cmn_pdiag_pll1_vco_ctrl_m1_11_8 — PLL VCO filter bandwidth trim
  [7] cmn_pdiag_pll1_vco_ctrl_m1_7 — PLL VCO initialization
  [6:4] cmn_pdiag_pll1_vco_ctrl_m1_6_4 — PLL VCO KVCO control
  [3:0] cmn_pdiag_pll1_vco_ctrl_m1_3_0 — PLL VCO voltage control initialization trim one hot:
0x754 cmn_pdiag_pll1_lock_det_ctrl_m1 — PLL 1 lock detect control register mode 1
  [31:6] cmn_pdiag_pll1_lock_det_ctrl_m1_31_6 ro — Reserved
  [5:0] cmn_pdiag_pll1_lock_det_ctrl_m1_5_0 — PLL lock detection depth control:
0x758 cmn_pdiag_pll1_post_div_m1 — PLL 1 post divide register mode 1
  [31:3] cmn_pdiag_pll1_post_div_m1_31_3 ro — Reserved
  [2:0] cmn_pdiag_pll1_post_div_m1_2_0
0x75C cmn_pdiag_pll1_ref_clk_div_sel_m1 — PLL 1 reference clock divide selection register mode 1
  [31:6] cmn_pdiag_pll1_ref_clk_div_sel_m1_31_6 ro — Reserved
  [5:0] cmn_pdiag_pll1_ref_clk_div_sel_m1_5_0 — PLL reference clock divide selection:
0x760 cmn_pdiag_pll1_prog0_clk_ctrl_m1 — PLL 1 programmable clock 0 control register mode 1
  [31] cmn_pdiag_pll1_prog0_clk_ctrl_m1_31 ro — Reserved
  [30:24] cmn_pdiag_pll1_prog0_clk_ctrl_m1_30_24 — PLL 1 programmable clock 0 divider integer low value (div int low):
  [23] cmn_pdiag_pll1_prog0_clk_ctrl_m1_23 ro — Reserved
  [22:16] cmn_pdiag_pll1_prog0_clk_ctrl_m1_22_16 — Note: The value of this field must be an even number.
  [15:12] cmn_pdiag_pll1_prog0_clk_ctrl_m1_15_12 ro — Reserved
  [11:8] cmn_pdiag_pll1_prog0_clk_ctrl_m1_11_8 — See the register description above for details about how this field is used to specify the divide ratio. Note: When the divider is in fractional mode 0, the maximum field this signal can be is 4'h7 (7) and when the divider is in fractional mode 1, the maximum value this field can be is 4'h7 (7).
  [7:3] cmn_pdiag_pll1_prog0_clk_ctrl_m1_7_3 ro — Reserved
  [2] cmn_pdiag_pll1_prog0_clk_ctrl_m1_2
  [1] cmn_pdiag_pll1_prog0_clk_ctrl_m1_1
  [0] cmn_pdiag_pll1_prog0_clk_ctrl_m1_0
0x764 cmn_pdiag_pll1_prog1_clk_ctrl_m1 — PLL 1 programmable clock 1 control register mode 1
  [31] cmn_pdiag_pll1_prog1_clk_ctrl_m1_31 ro — Reserved
  [30:24] cmn_pdiag_pll1_prog1_clk_ctrl_m1_30_24 — PLL 1 programmable clock 1 divider integer low value (div int low):
  [23] cmn_pdiag_pll1_prog1_clk_ctrl_m1_23 ro — Reserved
  [22:16] cmn_pdiag_pll1_prog1_clk_ctrl_m1_22_16 — Note: The value of this field must be an even number.
  [15:12] cmn_pdiag_pll1_prog1_clk_ctrl_m1_15_12 ro — Reserved
  [11:8] cmn_pdiag_pll1_prog1_clk_ctrl_m1_11_8 — Note: When the divider is in fractional mode 0, the maximum field this signal can be is 4'h7 (7) and when the divider is in fractional mode 1, the maximum value this field can be is 4'h7 (7).
  [7:3] cmn_pdiag_pll1_prog1_clk_ctrl_m1_7_3 ro — Reserved
  [2] cmn_pdiag_pll1_prog1_clk_ctrl_m1_2
  [1] cmn_pdiag_pll1_prog1_clk_ctrl_m1_1
  [0] cmn_pdiag_pll1_prog1_clk_ctrl_m1_0
0x780 cmn_diag_bandgap_ovrd reset 0x4 — Bandgap override register
  [31:16] cmn_diag_bandgap_ovrd_31_16 ro — Reserved
  [15:12] cmn_diag_bandgap_ovrd_15_12 ro — Reserved
  [11:8] cmn_diag_bandgap_ovrd_11_8 ro — Bandgap startup circuit startup count
  [7:4] cmn_diag_bandgap_ovrd_7_4 ro — Reserved
  [3:2] cmn_diag_bandgap_ovrd_3_2
  [1:0] cmn_diag_bandgap_ovrd_1_0 ro — Reserved
0x784 cmn_diag_bias_ovrd reset 0x4434 — Bias override register
  [31:28] cmn_diag_bias_ovrd_31_28 ro — Reserved
  [27:24] cmn_diag_bias_ovrd_27_24 ro — Reserved
  [23:22] cmn_diag_bias_ovrd_23_22 ro — Reserved
  [21] cmn_diag_bias_ovrd_21
  [20] cmn_diag_bias_ovrd_20 — Bias filter bypass enable override
  [19:18] cmn_diag_bias_ovrd_19_18 ro — Reserved
  [17:16] cmn_diag_bias_ovrd_17_16 ro — Reserved
  [15] cmn_diag_bias_ovrd_15 ro — Reserved
  [14:12] cmn_diag_bias_ovrd_14_12 — Note: The reset value is for that of a 100 ohm RX impedance target. For an 85 ohm RX impedance target, a value of 3'h5 should be used for this field.
  [11] cmn_diag_bias_ovrd_11 ro — Reserved
  [10:8] cmn_diag_bias_ovrd_10_8
  [7] cmn_diag_bias_ovrd_7 ro — Reserved
  [6:4] cmn_diag_bias_ovrd_6_4 — Note: The reset value is for that of a 100 ohm RX impedance target. For an 85 ohm RX impedance target, a value of 3'h2 should be used for this field.
  [3] cmn_diag_bias_ovrd_3 ro — Reserved
  [2:0] cmn_diag_bias_ovrd_2_0
0x788 cmn_diag_pm_ctrl — Process monitor control register
  [31:21] cmn_diag_pm_ctrl_31_21 ro — Reserved
  [20] cmn_diag_pm_ctrl_20
  [19] cmn_diag_pm_ctrl_19 ro — Reserved
  [18:16] cmn_diag_pm_ctrl_18_16
  [15:0] cmn_diag_pm_ctrl_15_0 ro — Reserved
0x78C cmn_diag_sh_bg_res — Sample and hold bandgap and resistor calibration code register
  [31:30] cmn_diag_sh_bg_res_31_30 ro — Reserved
  [29:24] cmn_diag_sh_bg_res_29_24 ro
  [23:21] cmn_diag_sh_bg_res_23_21 ro — Reserved
  [20:16] cmn_diag_sh_bg_res_20_16 ro — RX resistor code
  [15:6] cmn_diag_sh_bg_res_15_6 ro — Reserved
  [5] cmn_diag_sh_bg_res_5 ro — Bandgap up value
  [4:0] cmn_diag_sh_bg_res_4_0 ro
0x790 cmn_diag_sh_sdclk — Sample and hold signal detect clock calibration code register
  [31:16] cmn_diag_sh_sdclk_31_16 ro — Reserved
  [15:5] cmn_diag_sh_sdclk_15_5 ro — Reserved
  [4:0] cmn_diag_sh_sdclk_4_0 ro — Signal detect clock code
0x794 cmn_diag_atb_ctrl — ATB control register
  [31:29] cmn_diag_atb_ctrl_31_29 ro — Reserved
  [28:27] cmn_diag_atb_ctrl_28_27
  [26:22] cmn_diag_atb_ctrl_26_22 — ATB component sub address
  [21:16] cmn_diag_atb_ctrl_21_16 — ATB test point address
  [15:4] cmn_diag_atb_ctrl_15_4 ro — Reserved
  [3] cmn_diag_atb_ctrl_3
  [2] cmn_diag_atb_ctrl_2
  [1] cmn_diag_atb_ctrl_1
  [0] cmn_diag_atb_ctrl_0 — Note: There are master ATB switches in common and transceiver analog that must be enabled for an analog test point in the respective part of the design to be tested. These switches are controlled by the Common digital and analog cover your alternatives register described, and Transmitter analog cover your alternatives register described 7.
0x798 cmn_diag_atb_adc_ctrl — ATB ADC control register
  [31:30] cmn_diag_atb_adc_ctrl_31_30
  [29] cmn_diag_atb_adc_ctrl_29
  [28] cmn_diag_atb_adc_ctrl_28
  [27] cmn_diag_atb_adc_ctrl_27
  [26:25] cmn_diag_atb_adc_ctrl_26_25 ro — Reserved
  [24:20] cmn_diag_atb_adc_ctrl_24_20 — ATB ADC manual offset correction value :
  [19:16] cmn_diag_atb_adc_ctrl_19_16
  [15] cmn_diag_atb_adc_ctrl_15
  [14] cmn_diag_atb_adc_ctrl_14 — Start ATB ADC process
  [13] cmn_diag_atb_adc_ctrl_13 ro — ATB ADC process done
  [12:8] cmn_diag_atb_adc_ctrl_12_8 ro — Reserved
  [7:0] cmn_diag_atb_adc_ctrl_7_0 ro — ATB ADC data code
0x79C cmn_diag_hsrrsm_ctrl reset 0x81 — Common high speed reset release state machine control register
  [31:16] cmn_diag_hsrrsm_ctrl_31_16 ro — Reserved
  [15:8] cmn_diag_hsrrsm_ctrl_15_8 ro — Reserved
  [7:4] cmn_diag_hsrrsm_ctrl_7_4 — Transmitter reset pulse width
  [3:0] cmn_diag_hsrrsm_ctrl_3_0
0x7A0 cmn_diag_rst_diag — Common functions reset diagnostic register
  [31:16] cmn_diag_rst_diag_31_16 ro — Reserved
  [15:14] cmn_diag_rst_diag_15_14 ro — Reserved
  [13] cmn_diag_rst_diag_13 ro — Current state of the cmn_tmpsns_filt_reset_n reset.
  [12] cmn_diag_rst_diag_12 ro — Current state of the cmn_bgcal_reset_n reset.
  [11] cmn_diag_rst_diag_11 ro — Current state of the cmn_sd_clk_cal_fb_clk_reset_n reset.
  [10] cmn_diag_rst_diag_10 ro — Current state of the cmn_sd_clk_cal_ref_clk_reset_n reset.
  [9] cmn_diag_rst_diag_9 ro — Current state of the cmn_pll1_dsm_reset_n reset.
  [8] cmn_diag_rst_diag_8 ro — Current state of the cmn_pll1_vcocal_fbdiv_clk_reset_n reset.
  [7] cmn_diag_rst_diag_7 ro — Current state of the cmn_pll1_lock_det_fbdiv_clk_reset_n reset.
  [6] cmn_diag_rst_diag_6 ro — Current state of the cmn_pll1_vcocal_ref_clk_reset_n reset.
  [5] cmn_diag_rst_diag_5 ro — Current state of the cmn_pll1_lock_det_ref_clk_reset_n reset.
  [4] cmn_diag_rst_diag_4 ro — Current state of the cmn_pll0_dsm_reset_n reset.
  [3] cmn_diag_rst_diag_3 ro — Current state of the cmn_pll0_vcocal_fbdiv_clk_reset_n reset.
  [2] cmn_diag_rst_diag_2 ro — Current state of the cmn_pll0_lock_det_fbdiv_clk_reset_n reset.
  [1] cmn_diag_rst_diag_1 ro — Current state of the cmn_pll0_vcocal_ref_clk_reset_n reset.
  [0] cmn_diag_rst_diag_0 ro — Current state of the cmn_pll0_lock_det_ref_clk_reset_n reset.
0x7A4 cmn_diag_cya — Common digital and analog cover your alternatives register
  [31:16] cmn_diag_cya_31_16 ro — Reserved
  [15:0] cmn_diag_cya_15_0 — Reserved digital CYA bits - spare
0x7A8 cmn_diag_gpana_1 — Common analog general purpose control register 1
  [31:16] cmn_diag_gpana_1_31_16 — Note: Driven on cmnda_gpana_1_out[15:0]
  [15:0] cmn_diag_gpana_1_15_0 — Note: Driven on cmnda_gpana_0_out[15:0]
0x7AC cmn_diag_gpana_2 — Drives the cmnda_gpana_2_out signal to the analog.
  [31:16] cmn_diag_gpana_2_31_16 ro — Reserved
  [15:0] cmn_diag_gpana_2_15_0 — Reserved - spare
0x7B0 cmn_diag_gpana_st — Driven by the cmnda_gpana_in signal from the analog.
  [31:16] cmn_diag_gpana_st_31_16 ro — Reserved
  [15:0] cmn_diag_gpana_st_15_0 ro — Reserved - spare
0x7B4 cmn_diag_cal_filt_ctrl reset 0x33333 — Common analog calibration filter control register
  [31:26] cmn_diag_cal_filt_ctrl_31_26 ro — Reserved
  [n] cmn_diag_cal_filt_ctrl_{n} (n=21..25)
  [20:19] cmn_diag_cal_filt_ctrl_20_19 ro — Reserved
  [18:16] cmn_diag_cal_filt_ctrl_18_16
  [15] cmn_diag_cal_filt_ctrl_15 ro — Reserved
  [14:12] cmn_diag_cal_filt_ctrl_14_12
  [11] cmn_diag_cal_filt_ctrl_11 ro — Reserved
  [10:8] cmn_diag_cal_filt_ctrl_10_8
  [7] cmn_diag_cal_filt_ctrl_7 ro — Reserved
  [6:4] cmn_diag_cal_filt_ctrl_6_4
  [3] cmn_diag_cal_filt_ctrl_3 ro — Reserved
  [2:0] cmn_diag_cal_filt_ctrl_2_0
0x7B8 cmn_diag_mom_osc_ctrl — Common analog MOM cap oscillator control register
  [31:20] cmn_diag_mom_osc_ctrl_31_20 ro — Reserved
  [19:16] cmn_diag_mom_osc_ctrl_19_16
  [15:14] cmn_diag_mom_osc_ctrl_15_14 ro — Reserved
  [13:8] cmn_diag_mom_osc_ctrl_13_8
  [7:6] cmn_diag_mom_osc_ctrl_7_6 ro — Reserved
  [5] cmn_diag_mom_osc_ctrl_5 — MOM cap oscillator global flip enable:
  [4] cmn_diag_mom_osc_ctrl_4 — MOM cap oscillator flip selection:
  [n] cmn_diag_mom_osc_ctrl_{n} (n=0..3)
0x7BC cmn_diag_bias_adj reset 0x1400 — Common analog bias adjust register
  [31:17] cmn_diag_bias_adj_31_17 ro — Reserved
  [16] cmn_diag_bias_adj_16
  [15] cmn_diag_bias_adj_15 ro — Reserved
  [14] cmn_diag_bias_adj_14
  [13:12] cmn_diag_bias_adj_13_12
  [11] cmn_diag_bias_adj_11 ro — Reserved
  [10:8] cmn_diag_bias_adj_10_8
  [7:0] cmn_diag_bias_adj_7_0 ro — Reserved
0x7C0 cmn_diag_tmpsns_ana_ctrl reset 0x3000 — Common temperature sensor analog control register
  [31:25] cmn_diag_tmpsns_ana_ctrl_31_25 ro — Reserved
  [24] cmn_diag_tmpsns_ana_ctrl_24 ro — Temperature sensor serial data steam
  [23:22] cmn_diag_tmpsns_ana_ctrl_23_22 ro — Reserved
  [21] cmn_diag_tmpsns_ana_ctrl_21 — Temperature sensor disable amp control
  [20:16] cmn_diag_tmpsns_ana_ctrl_20_16
  [15:12] cmn_diag_tmpsns_ana_ctrl_15_12 — Cadence note: The value of 4'h8 used to be the maximum value, but an encoding error was found long after many tape outs. It was agreed that we would just change the documentation to address this.
  [11:8] cmn_diag_tmpsns_ana_ctrl_11_8
  [7:4] cmn_diag_tmpsns_ana_ctrl_7_4
  [n] cmn_diag_tmpsns_ana_ctrl_{n} (n=0..3)
0x7C4 cmn_diag_tmpsns_filt_ctrl reset 0x91000 — Common temperature sensor filter control register
  [31] cmn_diag_tmpsns_filt_ctrl_31 — Note: This bit, along with the temperature sensor filter done bit in this register make up a fully asynchronous handshake. Once this bit is set to 1'b1, it must remain set to 1'b1 until the done bit is detected as being 1'b1. After this event, this bit can be set to 1'b0, and must not be changed again until the done bit is detected as being 1'b0.
  [30] cmn_diag_tmpsns_filt_ctrl_30 ro
  [29:28] cmn_diag_tmpsns_filt_ctrl_29_28 ro — Reserved
  [27:21] cmn_diag_tmpsns_filt_ctrl_27_21 ro — Reserved
  [20:16] cmn_diag_tmpsns_filt_ctrl_20_16 — Note: There are a total of 5 elements in the filter that are triggered. Therefore, the minimum value this field must be before seeing the first filter output is 5.
  [15:14] cmn_diag_tmpsns_filt_ctrl_15_14 ro — Reserved
  [13:0] cmn_diag_tmpsns_filt_ctrl_13_0 — Temperature sensor filter trigger delay count
0x7C8 cmn_diag_tmpsns_filt_out — Common temperature sensor filter output register
  [31:16] cmn_diag_tmpsns_filt_out_31_16 ro — Reserved
  [15:0] cmn_diag_tmpsns_filt_out_15_0 ro — Note: This field is only valid when the temperature sensor filter done bit in the Common temperature sensor filter control register register described register is active. When the run temperature sensor filter bit in that register is cleared, the contents of this register will be cleared.
